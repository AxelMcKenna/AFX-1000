# Repository AxelMcKenna/AFX-1000 (continued)

## KiCad design hardware/fabrication/staging/two-board-power-fan-monitor-supply-branches-126/power_protection.kicad_pcb (continued)

Schematic: E_rail_disconnect.kicad_sch, Standalone RMX - rail_disconnect

Parts:
E_C1, E_C5, E_C9, E_C13, E_C17, E_C21, E_C25, E_C29, E_C34, E_C35, E_C36, E_C37, E_C57, E_C58, E_C59, E_C66, E_C67, E_C68, E_C69, E_C70, E_C71, E_C72, E_C73, E_C74, E_C75, E_C76, E_C77: 100nF 16V X7R; C_0805_2012Metric
E_C2, E_C3, E_C6, E_C7, E_C10, E_C11, E_C14, E_C15: 10pF 100V C0G 5%; C_0805_2012Metric
E_C4, E_C8: 1500uF 35V electrolytic 20% EEUFR1V152S; CP_Radial_D16.0mm_P7.50mm
E_C12, E_C16: 220uF 35V electrolytic 20% EEUFR1V221; CP_Radial_D8.0mm_P3.50mm
E_C20: 1500uF 16V electrolytic 20% EEUFR1C152; CP_Radial_D10.0mm_P5.00mm
E_C24: 4700uF 16V electrolytic 20% EEUFR1C472; CP_Radial_D16.0mm_P7.50mm
E_C26: 1uF 16V X7R; C_0805_2012Metric
E_C27, E_C28, E_C30, E_C31, E_C32, E_C33, E_C53, E_C54, E_C55, E_C56: 100pF 50V C0G 5%; C_0805_2012Metric
E_C38: 10uF 16V X7R; C_0805_2012Metric
E_C39, E_C41, E_C49, E_C61, E_C62, E_C63, E_C64, E_C65: 100nF 50V C0G 5% C1210C104J5GACTU; KEMET_C1210_LevelB
E_C40, E_C42, E_C44, E_C46, E_C48, E_C50, E_C52: 1uF 50V X7R; C_0805_2012Metric
E_C43, E_C45, E_C47, E_C51: 47nF 50V C0G 5% C1206C473J5GACTU; KEMET_C1206_LevelB
E_C60: 10nF 50V C0G 5%; C_0805_2012Metric
E_C78, E_C80, E_C81, E_C82, E_C83, E_C84, E_C85: 100nF 16V X7R 10% KEMET C0603C104K4RACTU; KEMET_C0603_LevelB
E_C79: 100nF 16V X7R 10% KEMET C0402C104K4RACTU; KEMET_C0402_LevelB
E_C86: 100nF 50V X7R C0603C104K5RACTU; AX03_C0603
E_J1, E_J3: Header6; PinHeader_1x06_P2.54mm_Vertical
E_J4: Alpha3079_AWG14_DIG_FORCE; AWG14_Force_2x1_P9mm_Engineering
E_J5, E_J6: Header3; PinHeader_1x03_P2.54mm_Vertical
E_J7, E_J8, E_J10, E_J11: 7466003R; 7466003R_M3_SMT_Annulus_NPTH
E_J9: E28 CONTROL; PinHeader_1x05_P2.54mm_Vertical
E_J12: JST B2B-PH-SM4-TB(LF)(SN); JST_B2B_PH_SM4_TB_MechanicalLands
E_Q1, E_Q2, E_Q3, E_Q4, E_Q5, E_Q6, E_Q7, E_Q8: CSD18540Q5B; CSD18540Q5B_TI_Q5B
E_R1, E_R9, E_R17, E_R25: 22 1%; R_0805_2012Metric
E_R2, E_R10, E_R18, E_R26, E_R60, E_R63, E_R68, E_R71, E_R76, E_R81, E_R86, E_R91: 20M 1%; R_0805_2012Metric
E_R3, E_R5, E_R11, E_R13, E_R19, E_R21, E_R27, E_R29, E_R61, E_R64, E_R69, E_R72, E_R77, E_R82, E_R87, E_R92: 10k 1%; R_0805_2012Metric
E_R4, E_R12, E_R20, E_R28, E_R98, E_R102, E_R106, E_R110, E_R114, E_R118, E_R122: 100 1%; R_0805_2012Metric
E_R6, E_R7, E_R14, E_R15, E_R22, E_R23, E_R30, E_R31: 15k 1%; R_0805_2012Metric
E_R8, E_R16, E_R24, E_R32, E_R40, E_R48: 47k 1%; R_0805_2012Metric
E_R49: 150k 0.01% 5ppm; R_0805_2012Metric
E_R50: 6.2k 0.01% 5ppm; R_0805_2012Metric
E_R51, E_R54, E_R58, E_R59, E_R62, E_R66, E_R67, E_R70, E_R74, E_R75, E_R79, E_R80, E_R84, E_R85, E_R89, E_R90, E_R94, E_R124, E_R127, E_R130, E_R133: 10k 0.01% 5ppm; R_0805_2012Metric
E_R52, E_R55: 1k 1%; R_0805_2012Metric
E_R53: 100k 0.01% 5ppm; R_0805_2012Metric
E_R56: 143k 0.01% 5ppm; R_0805_2012Metric
E_R57: 3.3k 0.01% 5ppm; R_0805_2012Metric
E_R65: 90.9k 0.01% 5ppm; R_0805_2012Metric
E_R73, E_R78: 31.6k 0.01% 5ppm; R_0805_2012Metric
E_R83: 12.4k 0.01% 5ppm; R_0805_2012Metric
E_R88: 7.5k 0.01% 5ppm; R_0805_2012Metric
E_R93: 200k 0.1% ERA6AEB204V - COMPLETE1% RECEIVING; R_0805_2012Metric
E_R95, E_R99, E_R103, E_R107, E_R111, E_R115, E_R119, E_R125, E_R128, E_R131, E_R134, E_R136, E_R141: 10k; R_0805_2012Metric
E_R96, E_R100, E_R104, E_R108, E_R112, E_R116, E_R120, E_R140: 47k; R_0805_2012Metric
E_R97, E_R101, E_R117: 2.43k 0.1%; R_0805_2012Metric
E_R105, E_R109, E_R113, E_R121: 604 0.1%; R_0805_2012Metric
E_R123, E_R126, E_R129, E_R132: 28.7k 0.01% 5ppm; R_0805_2012Metric
E_R135: 10k 0.1% 25ppm Panasonic ERA6AEB103V; Resistor_SMD_Panasonic_ERA6A_2012
E_R137: 11.1k 0.1%; R_0805_2012Metric
E_R138: 39.2 0.1%; R_0805_2012Metric
E_R139: 10k 0.1%; R_0805_2012Metric
E_R142: 15k; R_0805_2012Metric
E_R143: 15k 0.1% 25ppm Panasonic ERA6AEB153V; Resistor_SMD_Panasonic_ERA6A_2012
E_U1, E_U2, E_U3, E_U4: SI8751AB-ISR; SOIC-8_3.9x4.9mm_P1.27mm
E_U7: REF35125QDBVR; SOT-23-6
E_U8: OPA2333AID; SOIC-8_3.9x4.9mm_P1.27mm
E_U9, E_U10: TLV1824DR; SOIC-14_3.9x8.7mm_P1.27mm
E_U11, E_U12, E_U24, E_U25, E_U26, E_U27: SN74LVC08APWR; TSSOP-14_4.4x5mm_P0.65mm
E_U13, E_U14, E_U15, E_U16, E_U17, E_U32, E_U33: TPS259482LYWP; TPS259482L_YWP0012A
E_U18: TLV1824PWR; TLV1824_PW0014A
E_U19, E_U20: TPS389001DSET; TPS389001_DSE0006A
E_U21, E_U22: SN74LVC02APWR; TSSOP-14_4.4x5mm_P0.65mm
E_U23: SN74LVC32APWR; TSSOP-14_4.4x5mm_P0.65mm
E_U28: SN74LVC14APWR; SN74LVC14A_PW0014A
E_U29, E_U30, E_U31, E_U34: SN74AUP2G08DCUR; SN74AUP2G08_DCU0008A
E_U35, E_U36, E_U37, E_U38, E_U39, E_U40, E_U41: SN74AUP3G17DCUR; SN74LVC3G17_DCU0008A
E_U42: SN74LVC3G17DCUR; SN74LVC3G17_DCU0008A
E_U43: SN74AUP1G17DCKR; AX03_DCK0005A

Connections:
/E_rail_disconnect/5V_DIG_OV_OK: E_R81.1, E_R82.2, E_U10.1 (2OUT), E_U37.6 (3A)
/E_rail_disconnect/5V_DIG_OV_OK_SCHMITT: E_U11.10 (3B), E_U37.2 (3Y)
/E_rail_disconnect/5V_DIG_OV_REF: E_R80.2, E_R81.2, E_U10.7 (2+)
/E_rail_disconnect/5V_DIG_OV_SENSE: E_C33.1, E_R78.2, E_R79.1, E_U10.6 (2-)
/E_rail_disconnect/ANA_OUTPUT_OK: E_R131.2, E_U18.14 (UV_OK), E_U39.3 (2A)
/E_rail_disconnect/ANA_OUTPUT_OK_SCHMITT: E_U24.4 (A), E_U39.5 (2Y)
/E_rail_disconnect/ANA_PG0: E_R95.1, E_U13.3 (SPLYGD), E_U41.3 (2A)
/E_rail_disconnect/ANA_PG0_SCHMITT: E_U31.2 (B), E_U41.5 (2Y)
/E_rail_disconnect/ANA_PG1: E_R99.1, E_U14.3 (SPLYGD), E_U41.6 (3A)
/E_rail_disconnect/ANA_PG1_SCHMITT: E_U34.6 (B), E_U41.2 (3Y)
/E_rail_disconnect/ANA_PG2: E_R115.1, E_U32.3 (SPLYGD), E_U42.1 (1A)
/E_rail_disconnect/ANA_PG2_SCHMITT: E_U26.10 (B), E_U42.7 (1Y)
/E_rail_disconnect/ANA_SOURCE_OK: E_R125.2, E_U18.2 (UV_OK), E_U38.6 (3A)
/E_rail_disconnect/ANA_SOURCE_OK_SCHMITT: E_U24.1 (A), E_U38.2 (3Y)
/E_rail_disconnect/DIG_OUTPUT_OK: E_R134.2, E_U18.13 (UV_OK), E_U39.6 (3A)
/E_rail_disconnect/DIG_OUTPUT_OK_SCHMITT: E_U24.5 (B), E_U39.2 (3Y)
/E_rail_disconnect/DIG_PG0: E_R103.1, E_U15.3 (SPLYGD), E_U40.1 (1A)
/E_rail_disconnect/DIG_PG0_SCHMITT: E_U29.6 (B), E_U40.7 (1Y)
/E_rail_disconnect/DIG_PG1: E_R107.1, E_U16.3 (SPLYGD), E_U40.3 (2A)
/E_rail_disconnect/DIG_PG1_SCHMITT: E_U30.2 (B), E_U40.5 (2Y)
/E_rail_disconnect/DIG_PG2: E_R111.1, E_U17.3 (SPLYGD), E_U40.6 (3A)
/E_rail_disconnect/DIG_PG2_SCHMITT: E_U34.1 (A), E_U40.2 (3Y)
/E_rail_disconnect/DIG_PG3: E_R119.1, E_U33.3 (SPLYGD), E_U41.1 (1A)
/E_rail_disconnect/DIG_PG3_SCHMITT: E_U26.9 (A), E_U30.6 (B), E_U41.7 (1Y)
/E_rail_disconnect/DIG_SOURCE_OK: E_R128.2, E_U18.1 (UV_OK), E_U39.1 (1A)
/E_rail_disconnect/DIG_SOURCE_OK_SCHMITT: E_U24.2 (B), E_U39.7 (1Y)
/E_rail_disconnect/E28_ALL_CHANNELS_READY: E_U26.8 (Y), E_U26.12 (A)
/E_rail_disconnect/E28_ANA_0_DVDT: E_R98.1, E_U13.7 (DVDT)
/E_rail_disconnect/E28_ANA_0_DVDT_CAP: E_C39.1, E_R98.2
/E_rail_disconnect/E28_ANA_0_ILM: E_R97.1, E_U13.9 (ILM)
/E_rail_disconnect/E28_ANA_1_DVDT: E_R102.1, E_U14.7 (DVDT)
/E_rail_disconnect/E28_ANA_1_DVDT_CAP: E_C41.1, E_R102.2
/E_rail_disconnect/E28_ANA_1_ILM: E_R101.1, E_U14.9 (ILM)
/E_rail_disconnect/E28_ANA_2_DVDT: E_R118.1, E_U32.7 (DVDT)
/E_rail_disconnect/E28_ANA_2_DVDT_CAP: E_C49.1, E_R118.2
/E_rail_disconnect/E28_ANA_2_ILM: E_R117.1, E_U32.9 (ILM)
/E_rail_disconnect/E28_ANA_ENABLE: E_R96.1, E_U13.1 (EN_UVLO), E_U30.3 (Y)
/E_rail_disconnect/E28_ANA_FOLLOW: E_R100.1, E_U14.1 (EN_UVLO), E_U31.7 (Y)
/E_rail_disconnect/E28_ANA_FOLLOW2: E_R116.1, E_U32.1 (EN_UVLO), E_U34.3 (Y)
/E_rail_disconnect/E28_ANA_OUT_SENSE: E_C55.1, E_R129.2, E_R130.1, E_U18.9 (SENSE+)
/E_rail_disconnect/E28_ANA_SRC_SENSE: E_C53.1, E_R123.2, E_R124.1, E_U18.5 (SENSE+)
/E_rail_disconnect/E28_ARMED: E_U21.3 (B), E_U21.4 (Y), E_U25.9 (A)
/E_rail_disconnect/E28_ARM_BAR: E_U21.1 (Y), E_U21.6 (B)
/E_rail_disconnect/E28_AUX_CT: E_C60.1, E_U19.5 (CT)
/E_rail_disconnect/E28_AUX_DIV: E_R137.2, E_R138.1
/E_rail_disconnect/E28_AUX_RESET_N: E_U31.5 (A), E_U35.5 (2Y)
/E_rail_disconnect/E28_AUX_RESET_RAW: E_R135.1, E_U19.6 (RESET_N), E_U35.3 (2A)
/E_rail_disconnect/E28_AUX_SENSE: E_R138.2, E_R139.1, E_U19.1 (SENSE)
/E_rail_disconnect/E28_DIG_0_DVDT: E_R106.1, E_U15.7 (DVDT)
/E_rail_disconnect/E28_DIG_0_DVDT_CAP: E_C43.1, E_R106.2
/E_rail_disconnect/E28_DIG_0_ILM: E_R105.1, E_U15.9 (ILM)
/E_rail_disconnect/E28_DIG_1_DVDT: E_R110.1, E_U16.7 (DVDT)
/E_rail_disconnect/E28_DIG_1_DVDT_CAP: E_C45.1, E_R110.2
/E_rail_disconnect/E28_DIG_1_ILM: E_R109.1, E_U16.9 (ILM)
/E_rail_disconnect/E28_DIG_2_DVDT: E_R114.1, E_U17.7 (DVDT)
/E_rail_disconnect/E28_DIG_2_DVDT_CAP: E_C47.1, E_R114.2
/E_rail_disconnect/E28_DIG_2_ILM: E_R113.1, E_U17.9 (ILM)
/E_rail_disconnect/E28_DIG_3_DVDT: E_R122.1, E_U33.7 (DVDT)
/E_rail_disconnect/E28_DIG_3_DVDT_CAP: E_C51.1, E_R122.2
/E_rail_disconnect/E28_DIG_3_ILM: E_R121.1, E_U33.9 (ILM)
/E_rail_disconnect/E28_DIG_FOLLOW1: E_R108.1, E_U16.1 (EN_UVLO), E_U29.3 (Y)
/E_rail_disconnect/E28_DIG_FOLLOW2: E_R112.1, E_U17.1 (EN_UVLO), E_U30.7 (Y)
/E_rail_disconnect/E28_DIG_FOLLOW3: E_R120.1, E_U33.1 (EN_UVLO), E_U34.7 (Y)
/E_rail_disconnect/E28_DIG_OUT_SENSE: E_C56.1, E_R132.2, E_R133.1, E_U18.11 (SENSE+)
/E_rail_disconnect/E28_DIG_SRC_SENSE: E_C54.1, E_R126.2, E_R127.1, E_U18.7 (SENSE+)
/E_rail_disconnect/E28_FAULT: E_J9.4 (E28_FAULT), E_U21.9 (B), E_U21.13 (Y), E_U23.5 (B), E_U28.5 (A)
/E_rail_disconnect/E28_FAULT_A: E_U23.8 (Y), E_U23.12 (A)
/E_rail_disconnect/E28_FAULT_ANY: E_U23.11 (Y), E_U25.10 (B)
/E_rail_disconnect/E28_FAULT_BAR: E_U21.10 (Y), E_U21.12 (B)
/E_rail_disconnect/E28_MASTER_ENABLE: E_J6.2 (ALL_RAILS_ALLOW), E_J9.5 (E28_MASTER_ENABLE), E_R4.1, E_R12.1, E_R20.1, E_R28.1, E_R104.1, E_R141.1, E_U15.1 (EN_UVLO), E_U20.1 (SENSE), E_U20.3 (MR_N), E_U25.13 (B), E_U27.2 (B), E_U29.5 (A), E_U29.7 (Y), E_U30.1 (A), E_U30.5 (A), E_U31.1 (A), E_U34.2 (B), E_U34.5 (A)
/E_rail_disconnect/E28_NORMAL_OK: E_U22.8 (A), E_U27.8 (Y)
/E_rail_disconnect/E28_NORMAL_PRE: E_U24.8 (Y), E_U27.9 (A)
/E_rail_disconnect/E28_NOT_AUX: E_U23.2 (B), E_U28.4 (Y)
/E_rail_disconnect/E28_NOT_NORMAL_OK: E_U22.10 (Y), E_U23.9 (A)
/E_rail_disconnect/E28_NOT_OUT_READY: E_U22.13 (Y), E_U26.2 (B), E_U26.5 (B)
/E_rail_disconnect/E28_NOT_RUN: E_U23.1 (A), E_U28.2 (Y), E_U28.9 (A)
/E_rail_disconnect/E28_NOT_SOURCE_READY: E_U28.10 (Y), E_U28.13 (A)
/E_rail_disconnect/E28_OUTPUT_PERMISSION: E_U26.11 (Y), E_U27.1 (A)
/E_rail_disconnect/E28_OUTPUT_READY: E_J9.3 (E28_OUTPUT_READY), E_U25.6 (Y)
/E_rail_disconnect/E28_OUT_ARMED: E_U22.3 (B), E_U22.4 (Y), E_U26.1 (A)
/E_rail_disconnect/E28_OUT_ARM_BAR: E_U22.1 (Y), E_U22.6 (B)
/E_rail_disconnect/E28_OUT_READY: E_U22.11 (A), E_U24.6 (Y), E_U25.12 (A), E_U26.13 (B)
/E_rail_disconnect/E28_OUT_UV_FAULT: E_U23.10 (B), E_U26.3 (Y)
/E_rail_disconnect/E28_OUT_VALID_ACTIVE: E_U22.2 (A), E_U25.11 (Y)
/E_rail_disconnect/E28_RESET_OUT: E_U22.5 (A), E_U23.6 (Y)
/E_rail_disconnect/E28_RUN_AND_SOURCE: E_U24.12 (A), E_U27.6 (Y)
/E_rail_disconnect/E28_RUN_LOGIC: E_U27.4 (A), E_U28.8 (Y)
/E_rail_disconnect/E28_SAFE_REQUEST: E_R140.1, E_U12.13 (4B), E_U27.11 (Y)
/E_rail_disconnect/E28_SAFE_STAGE: E_U25.3 (Y), E_U27.12 (A)
/E_rail_disconnect/E28_SOURCE_READY: E_U24.3 (Y), E_U24.9 (A), E_U25.2 (B)
/E_rail_disconnect/E28_SOURCE_READY_LOGIC: E_U27.5 (B), E_U27.10 (B), E_U28.12 (Y)
/E_rail_disconnect/E28_TIMEOUT: E_U26.4 (A), E_U35.7 (1Y)
/E_rail_disconnect/E28_TIMEOUT_CT: E_C61.1, E_C62.1, E_C63.1, E_C64.1, E_C65.1, E_U20.5 (CT)
/E_rail_disconnect/E28_TIMEOUT_FAULT: E_U23.13 (B), E_U26.6 (Y)
/E_rail_disconnect/E28_TIMEOUT_RAW: E_R136.1, E_U20.6 (RESET_N), E_U35.1 (1A)
/E_rail_disconnect/E28_USER_AUX: E_U24.11 (Y), E_U25.1 (A)
/E_rail_disconnect/N12_ALLOW: E_R28.2, E_R29.1, E_U4.3 (IN)
/E_rail_disconnect/N12_DRIVE: E_R25.1, E_U4.8 (GATE)
/E_rail_disconnect/N12_INV: E_R54.1, E_R55.1, E_U8.7 (OUT_B)
/E_rail_disconnect/N12_MCAP1: E_C14.2, E_U4.7 (MCAP1)
/E_rail_disconnect/N12_MCAP1_LIMIT: E_C14.1, E_R30.2
/E_rail_disconnect/N12_MCAP2: E_C15.2, E_U4.6 (MCAP2)
/E_rail_disconnect/N12_MCAP2_LIMIT: E_C15.1, E_R31.2
/E_rail_disconnect/N12_OV_OK_SCHMITT: E_U11.4 (2A), E_U37.7 (1Y)
/E_rail_disconnect/N12_OV_REF: E_R70.2, E_R71.2, E_U9.11 (4+)
/E_rail_disconnect/N12_SUM: E_R53.2, E_R54.2, E_U8.6 (IN-_B)
/E_rail_disconnect/N12_TT: E_R27.1, E_U4.2 (TT)
/E_rail_disconnect/N19_ALLOW: E_R12.2, E_R13.1, E_U2.3 (IN)
/E_rail_disconnect/N19_DRIVE: E_R9.1, E_U2.8 (GATE)
/E_rail_disconnect/N19_INPUT_MID: E_R49.2, E_R50.1
/E_rail_disconnect/N19_INV: E_R51.1, E_R52.1, E_U8.1 (OUT_A)
/E_rail_disconnect/N19_MCAP1: E_C6.2, E_U2.7 (MCAP1)
/E_rail_disconnect/N19_MCAP1_LIMIT: E_C6.1, E_R14.2
/E_rail_disconnect/N19_MCAP2: E_C7.2, E_U2.6 (MCAP2)
/E_rail_disconnect/N19_MCAP2_LIMIT: E_C7.1, E_R15.2
/E_rail_disconnect/N19_OV_OK_SCHMITT: E_U11.1 (1A), E_U36.5 (2Y)
/E_rail_disconnect/N19_OV_REF: E_R62.2, E_R63.2, E_U9.7 (2+)
/E_rail_disconnect/N19_SUM: E_R50.2, E_R51.2, E_U8.2 (IN-_A)
/E_rail_disconnect/N19_TT: E_R11.1, E_U2.2 (TT)
/E_rail_disconnect/NF_VALID_LOGIC: E_U25.5 (B), E_U35.2 (3Y)
/E_rail_disconnect/OK_5: E_U11.8 (3Y), E_U12.4 (2A)
/E_rail_disconnect/OK_12: E_U11.6 (2Y), E_U12.2 (1B)
/E_rail_disconnect/OK_19: E_U11.3 (1Y), E_U12.1 (1A)
/E_rail_disconnect/OK_ALL_OV: E_U12.8 (3Y), E_U12.12 (4A), E_U24.10 (B)
/E_rail_disconnect/OK_ANALOG: E_U12.3 (1Y), E_U12.9 (3A)
/E_rail_disconnect/OK_AUXILIARY: E_U12.6 (2Y), E_U12.10 (3B)
/E_rail_disconnect/OK_REF: E_U11.11 (4Y), E_U12.5 (2B)
/E_rail_disconnect/P12_ALLOW: E_R20.2, E_R21.1, E_U3.3 (IN)
/E_rail_disconnect/P12_COMMON: E_Q5.1 (SOURCE_GROUP), E_Q6.1 (SOURCE_GROUP), E_R18.2, E_U3.5 (SOURCE)
/E_rail_disconnect/P12_DRIVE: E_R17.1, E_U3.8 (GATE)
/E_rail_disconnect/P12_GATE: E_Q5.2 (GATE_GROUP), E_Q6.2 (GATE_GROUP), E_R17.2, E_R18.1
/E_rail_disconnect/P12_MCAP1: E_C10.2, E_U3.7 (MCAP1)
/E_rail_disconnect/P12_MCAP1_LIMIT: E_C10.1, E_R22.2
/E_rail_disconnect/P12_MCAP2: E_C11.2, E_U3.6 (MCAP2)
/E_rail_disconnect/P12_MCAP2_LIMIT: E_C11.1, E_R23.2
/E_rail_disconnect/P12_OV_OK: E_R68.1, E_R69.2, E_U9.14 (3OUT), E_U36.6 (3A)
/E_rail_disconnect/P12_OV_OK_SCHMITT: E_U11.5 (2B), E_U36.2 (3Y)
/E_rail_disconnect/P12_OV_REF: E_R67.2, E_R68.2, E_U9.9 (3+)
/E_rail_disconnect/P12_OV_SENSE: E_C31.1, E_R65.2, E_R66.1, E_U9.8 (3-)
/E_rail_disconnect/P12_TT: E_R19.1, E_U3.2 (TT)
/E_rail_disconnect/P19_ALLOW: E_R4.2, E_R5.1, E_U1.3 (IN)
/E_rail_disconnect/P19_COMMON: E_Q1.1 (SOURCE_GROUP), E_Q2.1 (SOURCE_GROUP), E_R2.2, E_U1.5 (SOURCE)
/E_rail_disconnect/P19_DRIVE: E_R1.1, E_U1.8 (GATE)
/E_rail_disconnect/P19_GATE: E_Q1.2 (GATE_GROUP), E_Q2.2 (GATE_GROUP), E_R1.2, E_R2.1
/E_rail_disconnect/P19_MCAP1: E_C2.2, E_U1.7 (MCAP1)
/E_rail_disconnect/P19_MCAP1_LIMIT: E_C2.1, E_R6.2
/E_rail_disconnect/P19_MCAP2: E_C3.2, E_U1.6 (MCAP2)
/E_rail_disconnect/P19_MCAP2_LIMIT: E_C3.1, E_R7.2
/E_rail_disconnect/P19_OV_OK: E_R60.1, E_R61.2, E_U9.2 (1OUT), E_U36.1 (1A)
/E_rail_disconnect/P19_OV_OK_SCHMITT: E_U11.2 (1B), E_U36.7 (1Y)
/E_rail_disconnect/P19_OV_REF: E_R59.2, E_R60.2, E_U9.5 (1+)
/E_rail_disconnect/P19_OV_SENSE: E_C30.1, E_R57.2, E_R58.1, E_U9.4 (1-)
/E_rail_disconnect/P19_SENSE_MID: E_R56.2, E_R57.1
/E_rail_disconnect/P19_TT: E_R3.1, E_U1.2 (TT)
/E_rail_disconnect/POS_OUTPUT_READY: E_U25.4 (A), E_U27.3 (Y)
/E_rail_disconnect/REF_HIGH_AUX: E_R88.2, E_R89.1, E_R90.1
/E_rail_disconnect/REF_HIGH_OK: E_R91.1, E_R92.2, E_U10.13 (4OUT), E_U38.3 (2A)
/E_rail_disconnect/REF_HIGH_OK_SCHMITT: E_U11.13 (4B), E_U38.5 (2Y)
/E_rail_disconnect/REF_HIGH_POSITIVE: E_R90.2, E_R91.2, E_U10.11 (4+)
/E_rail_disconnect/REF_LOW_AUX: E_R83.2, E_R84.1, E_U10.8 (3-)
/E_rail_disconnect/REF_LOW_OK: E_R86.1, E_R87.2, E_U10.14 (3OUT), E_U38.1 (1A)
/E_rail_disconnect/REF_LOW_OK_SCHMITT: E_U11.12 (4A), E_U38.7 (1Y)
/E_rail_disconnect/REF_LOW_POSITIVE: E_R85.2, E_R86.2, E_U10.9 (3+)
/E_rail_disconnect/RUN_BUFFERED: E_U28.1 (A), E_U43.4 (Y)
/E_rail_disconnect/V5_REG_OV_OK: E_R76.1, E_R77.2, E_U10.2 (1OUT), E_U37.3 (2A)
/E_rail_disconnect/V5_REG_OV_OK_SCHMITT: E_U11.9 (3A), E_U37.5 (2Y)
/E_rail_disconnect/V5_REG_OV_REF: E_R75.2, E_R76.2, E_U10.5 (1+)
/E_rail_disconnect/V5_REG_OV_SENSE: E_C32.1, E_R73.2, E_R74.1, E_U10.4 (1-)
PWR_5V_DIG: E_C24.1, E_J4.1 (5V_DIG), E_R48.1, E_R132.1, E_U15.6 (OUT), E_U15.11 (OUT), E_U16.6 (OUT), E_U16.11 (OUT), E_U17.6 (OUT), E_U17.11 (OUT), E_U33.6 (OUT), E_U33.11 (OUT); also elsewhere on the board
PWR_5V_DIG_SRC: E_C44.1, E_C46.1, E_C48.1, E_C52.1, E_J11.1, E_R78.1, E_R126.1, E_U15.5 (IN), E_U15.12 (IN), E_U16.5 (IN), E_U16.12 (IN), E_U17.5 (IN), E_U17.12 (IN), E_U33.5 (IN), E_U33.12 (IN); also elsewhere on the board
PWR_AGND: E_C1.2, E_C4.2, E_C5.2, E_C8.1, E_C9.2, E_C12.2, E_C13.2, E_C16.1, E_C17.2, E_C20.2, E_C21.2, E_C24.2, E_C25.2, E_C26.2, E_C27.2, E_C28.2, E_C29.2, E_C30.2, E_C31.2, E_C32.2, E_C33.2, E_C34.2, E_C35.2, E_C36.2, E_C37.2, E_C38.2, E_C39.2, E_C40.2, E_C41.2, E_C42.2, E_C43.2, E_C44.2, E_C45.2, E_C46.2, E_C47.2, E_C48.2, E_C49.2, E_C50.2, E_C51.2, E_C52.2, E_C53.2, E_C54.2, E_C55.2, E_C56.2, E_C57.2, E_C58.2, E_C59.2, E_C60.2, E_C61.2, E_C62.2, E_C63.2, E_C64.2, E_C65.2, E_C66.2, E_C67.2, E_C68.2, E_C69.2, E_C70.2, E_C71.2, E_C72.2, E_C73.2, E_C74.2, E_C75.2, E_C76.2, E_C77.2, E_C78.2, E_C79.2, E_C80.2, E_C81.2, E_C82.2, E_C83.2, E_C84.2, E_C85.2, E_C86.2, E_J1.2 (AGND), E_J3.2 (AGND), E_J4.2 (AGND), E_J5.2 (AGND), E_J6.1 (AGND), E_J7.1, E_J8.1, E_J9.1 (AGND), E_J12.2 (AGND), E_R3.2, E_R5.2, E_R8.2, E_R11.2, E_R13.2, E_R16.2, E_R19.2, E_R21.2, E_R24.2, E_R27.2, E_R29.2, E_R32.2, E_R40.2, E_R48.2, E_R58.2, E_R66.2, E_R74.2, E_R79.2, E_R84.2, E_R89.2, E_R93.2, E_R94.2, E_R96.2, E_R97.2, E_R100.2, E_R101.2, E_R104.2, E_R105.2, E_R108.2, E_R109.2, E_R112.2, E_R113.2, E_R116.2, E_R117.2, E_R120.2, E_R121.2, E_R124.2, E_R127.2, E_R130.2, E_R133.2, E_R139.2, E_R140.2, E_R141.2, E_R142.2, E_R143.2, E_U1.4 (GND), E_U2.4 (GND), E_U3.4 (GND), E_U4.4 (GND), E_U7.1 (GND), E_U7.2 (GND), E_U8.3 (IN+_A), E_U8.4 (V-), E_U8.5 (IN+_B), E_U9.12 (V-), E_U10.12 (V-), E_U11.7 (GND), E_U12.7 (GND), E_U13.2 (OVLO), E_U13.4 (RCBCTRL), E_U13.8 (GND), E_U14.2 (OVLO), E_U14.4 (RCBCTRL), E_U14.8 (GND), E_U15.2 (OVLO), E_U15.4 (RCBCTRL), E_U15.8 (GND), E_U16.2 (OVLO), E_U16.4 (RCBCTRL), E_U16.8 (GND), E_U17.2 (OVLO), E_U17.4 (RCBCTRL), E_U17.8 (GND), E_U18.12 (V-), E_U19.2 (GND), E_U20.2 (GND), E_U21.7 (GND), E_U22.7 (GND), E_U22.9 (B), E_U22.12 (B), E_U23.7 (GND), E_U24.7 (GND), E_U25.7 (GND), E_U26.7 (GND), E_U27.7 (GND), E_U28.7 (GND), E_U29.4 (GND), E_U30.4 (GND), E_U31.4 (GND), E_U32.2 (OVLO), E_U32.4 (RCBCTRL), E_U32.8 (GND), E_U33.2 (OVLO), E_U33.4 (RCBCTRL), E_U33.8 (GND), E_U34.4 (GND), E_U35.4 (GND), E_U36.4 (GND), E_U37.4 (GND), E_U38.4 (GND), E_U39.4 (GND), E_U40.4 (GND), E_U41.4 (GND), E_U42.4 (GND), E_U43.3 (GND); also elsewhere on the board
PWR_ALL_RAILS_ALLOW: E_U12.11 (4Y), E_U21.2 (A), E_U29.1 (A), E_U42.3 (2A)
PWR_E28_AUX_VALID_NATIVE: E_U24.13 (B), E_U28.3 (A), E_U29.2 (B), E_U31.3 (Y), E_U42.6 (3A)
PWR_E28_COMBINED_FAULT_REQUEST: E_U21.8 (A); also elsewhere on the board
PWR_E28_NATIVE_FAULT_REQUEST: E_U25.8 (Y); also elsewhere on the board
PWR_E28_NOT_FAULT: E_U27.13 (B), E_U28.6 (Y); also elsewhere on the board
PWR_E28_RESET: E_U21.5 (A), E_U21.11 (A), E_U23.3 (Y), E_U23.4 (A); also elsewhere on the board
PWR_N12: E_C16.2, E_J3.5 (N12), E_Q8.3 (DRAIN_GROUP), E_R31.1, E_R32.1; also elsewhere on the board
PWR_N12_BANK_COMMON: E_Q7.1 (SOURCE_GROUP), E_Q8.1 (SOURCE_GROUP), E_R26.2, E_U4.5 (SOURCE); also elsewhere on the board
PWR_N12_BANK_GATE: E_Q7.2 (GATE_GROUP), E_Q8.2 (GATE_GROUP), E_R25.2, E_R26.1; also elsewhere on the board
PWR_N12_OV_OK: E_R71.1, E_R72.2, E_U9.13 (4OUT), E_U37.1 (1A); also elsewhere on the board
PWR_N12_OV_SENSE: E_C28.1, E_R55.2, E_U9.10 (4-); also elsewhere on the board
PWR_N12_POST_NF: E_J1.5 (N12_SRC), E_Q7.3 (DRAIN_GROUP), E_R30.1; also elsewhere on the board
PWR_N12_SOURCE: E_R53.1; also elsewhere on the board
PWR_N19: E_C8.2, E_J3.3 (N19), E_Q4.3 (DRAIN_GROUP), E_R15.1, E_R16.1; also elsewhere on the board
PWR_N19_BANK_COMMON: E_Q3.1 (SOURCE_GROUP), E_Q4.1 (SOURCE_GROUP), E_R10.2, E_U2.5 (SOURCE); also elsewhere on the board
PWR_N19_BANK_GATE: E_Q3.2 (GATE_GROUP), E_Q4.2 (GATE_GROUP), E_R9.2, E_R10.1; also elsewhere on the board
PWR_N19_OV_OK: E_R63.1, E_R64.2, E_U9.1 (2OUT), E_U36.3 (2A); also elsewhere on the board
PWR_N19_OV_SENSE: E_C27.1, E_R52.2, E_U9.6 (2-); also elsewhere on the board
PWR_N19_POST_NF: E_J1.3 (N19_SRC), E_Q3.3 (DRAIN_GROUP), E_R14.1; also elsewhere on the board
PWR_N19_SOURCE: E_R49.1; also elsewhere on the board
PWR_NF_AUX_VALID: E_U42.2 (3Y); also elsewhere on the board
PWR_NF_GLOBAL_MASTER: E_U42.5 (2Y); also elsewhere on the board
PWR_NF_OUTPUT_VALID: E_J12.1 (NF_OUTPUT_VALID_RAW), E_R143.1, E_U35.6 (3A); also elsewhere on the board
PWR_P03_SOURCES_READY: E_J9.2 (P03_SOURCES_READY), E_R142.1, E_U28.11 (A); also elsewhere on the board
PWR_P12: E_C12.1, E_J3.4 (P12), E_Q6.3 (DRAIN_GROUP), E_R23.1, E_R24.1; also elsewhere on the board
PWR_P12_SRC: E_J1.4 (P12_SRC), E_Q5.3 (DRAIN_GROUP), E_R22.1, E_R65.1; also elsewhere on the board
PWR_P19: E_C4.1, E_J3.1 (P19), E_Q2.3 (DRAIN_GROUP), E_R7.1, E_R8.1; also elsewhere on the board
PWR_P19_SRC: E_J1.1 (P19_SRC), E_Q1.3 (DRAIN_GROUP), E_R6.1, E_R56.1; also elsewhere on the board
PWR_PROTECT_REF: E_C26.1, E_J6.3 (PROTECT_REF), E_R59.1, E_R62.1, E_R67.1, E_R70.1, E_R75.1, E_R80.1, E_R85.1, E_R94.1, E_U7.6 (VREF), E_U10.10 (4-), E_U18.4 (REF-), E_U18.6 (REF-), E_U18.8 (REF-), E_U18.10 (REF-); also elsewhere on the board
PWR_RUN_AFTER_FAN: E_J5.3 (POWER_RUN), E_R93.1, E_U43.2 (A); also elsewhere on the board
PWR_V2V5_AUX: E_C1.1, E_C5.1, E_C9.1, E_C13.1, E_C17.1, E_C21.1, E_C25.1, E_C29.1, E_C34.1, E_C35.1, E_C36.1, E_C37.1, E_C38.1, E_C57.1, E_C58.1, E_C59.1, E_C66.1, E_C67.1, E_C68.1, E_C69.1, E_C70.1, E_C71.1, E_C72.1, E_C73.1, E_C74.1, E_C75.1, E_C76.1, E_C77.1, E_C78.1, E_C79.1, E_C80.1, E_C81.1, E_C82.1, E_C83.1, E_C84.1, E_C85.1, E_C86.1, E_J5.1 (V2V5_AUX), E_R61.1, E_R64.1, E_R69.1, E_R72.1, E_R77.1, E_R82.1, E_R83.1, E_R87.1, E_R88.1, E_R92.1, E_R95.2, E_R99.2, E_R103.2, E_R107.2, E_R111.2, E_R115.2, E_R119.2, E_R125.1, E_R128.1, E_R131.1, E_R134.1, E_R135.2, E_R136.2, E_R137.1, E_U1.1 (VDD), E_U2.1 (VDD), E_U3.1 (VDD), E_U4.1 (VDD), E_U7.3 (EN), E_U7.4 (VIN), E_U8.8 (V+), E_U9.3 (V+), E_U10.3 (V+), E_U11.14 (VCC), E_U12.14 (VCC), E_U18.3 (V+), E_U19.3 (MR_N), E_U19.4 (VDD), E_U20.4 (VDD), E_U21.14 (VCC), E_U22.14 (VCC), E_U23.14 (VCC), E_U24.14 (VCC), E_U25.14 (VCC), E_U26.14 (VCC), E_U27.14 (VCC), E_U28.14 (VCC), E_U29.8 (VCC), E_U30.8 (VCC), E_U31.6 (B), E_U31.8 (VCC), E_U34.8 (VCC), E_U35.8 (VCC), E_U36.8 (VCC), E_U37.8 (VCC), E_U38.8 (VCC), E_U39.8 (VCC), E_U40.8 (VCC), E_U41.8 (VCC), E_U42.8 (VCC), E_U43.5 (VCC); also elsewhere on the board
PWR_V5_REG: E_C20.1, E_J3.6 (V5_REG), E_R40.1, E_R129.1, E_U13.6 (OUT), E_U13.11 (OUT), E_U14.6 (OUT), E_U14.11 (OUT), E_U32.6 (OUT), E_U32.11 (OUT); also elsewhere on the board
PWR_V5_REG_SRC: E_C40.1, E_C42.1, E_C50.1, E_J1.6 (V5_REG_SRC), E_J10.1, E_R73.1, E_R123.1, E_U13.5 (IN), E_U13.12 (IN), E_U14.5 (IN), E_U14.12 (IN), E_U32.5 (IN), E_U32.12 (IN); also elsewhere on the board

Notes on the sheet:
E28LP lowpowerRUN prototype; original force/timing/latch topology retained; physical validation unfinished.

Schematic: M_rail_monitor.kicad_sch, Standalone RMX - rail-window qualification

Parts:
M_C1, M_C2, M_C3, M_C4, M_C5, M_C6, M_C7, M_C8, M_C9, M_C10, M_C11, M_C12, M_C13, M_C14, M_C15, M_C16, M_C17, M_C18, M_C19, M_C20, M_C21, M_C22, M_C23, M_C24, M_C25, M_C26, M_C27, M_C28, M_C29, M_C30, M_C31, M_C32, M_C33, M_C34, M_C35, M_C36: 100pF C0G 5%; C_0805_2012Metric
M_C37, M_C38, M_C39, M_C40, M_C41, M_C42, M_C43, M_C44, M_C45, M_C46, M_C47, M_C48: 100nF 16V X7R; C_0805_2012Metric
M_C49: 2.2uF 16V X7R; C_0805_2012Metric
M_C50: 10uF 16V X7R; C_0805_2012Metric
M_C51: 1uF 16V X7R; C_0805_2012Metric
M_J1, M_J3: Conn_01x03; PinHeader_1x03_P2.54mm_Vertical
M_J2: Conn_01x06; PinHeader_1x06_P2.54mm_Vertical
M_J4: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
M_R1, M_R7, M_R25, M_R31: 91k 0.01% 5ppm; R_0805_2012Metric
M_R2, M_R4, M_R8, M_R10, M_R11, M_R14, M_R16, M_R19, M_R21, M_R22, M_R26, M_R28, M_R32, M_R33, M_R35, M_R36, M_R39, M_R41, M_R44, M_R45, M_R47, M_R48, M_R51, M_R53, M_R56, M_R58, M_R59, M_R62, M_R64, M_R67, M_R69, M_R70, M_R73, M_R75, M_R77, M_R80, M_R82, M_R84, M_R85, M_R88, M_R90, M_R92, M_R96, M_R98, M_R99, M_R103, M_R105, M_R106, M_R108, M_R111: 10k 0.01% 5ppm; R_0805_2012Metric
M_R3: 3.57k 0.01% 5ppm; R_0805_2012Metric
M_R5, M_R12, M_R17, M_R23, M_R29, M_R37, M_R42, M_R49, M_R54, M_R60, M_R65, M_R71, M_R78, M_R86, M_R93, M_R100: 20M 1%; R_0805_2012Metric
M_R6, M_R13, M_R18, M_R24, M_R30, M_R38, M_R43, M_R50, M_R55, M_R61, M_R66, M_R72, M_R79, M_R87, M_R94, M_R101, M_R113: 10k 1%; R_0805_2012Metric
M_R9: 3.01k 0.01% 5ppm; R_0805_2012Metric
M_R15: 3.4k 0.01% 5ppm; R_0805_2012Metric
M_R20: 2.87k 0.01% 5ppm; R_0805_2012Metric
M_R27, M_R95: 11.5k 0.01% 5ppm; R_0805_2012Metric
M_R34: 604 0.01% 5ppm; R_0805_2012Metric
M_R40: 11.3k 0.01% 5ppm; R_0805_2012Metric
M_R46: 412 0.01% 5ppm; R_0805_2012Metric
M_R52, M_R63: 8.2k 0.01% 5ppm; R_0805_2012Metric
M_R57, M_R68: 1.78k 0.01% 5ppm; R_0805_2012Metric
M_R74, M_R81, M_R89: 499 0.01% 5ppm; R_0805_2012Metric
M_R76: 374 0.01% 5ppm; R_0805_2012Metric
M_R83: 127 0.01% 5ppm; R_0805_2012Metric
M_R91: 768 0.01% 5ppm; R_0805_2012Metric
M_R97: 270 0.01% 5ppm; R_0805_2012Metric
M_R102, M_R104: 100k 0.01% 5ppm; R_0805_2012Metric
M_R107, M_R109: 80.6k 0.01% 5ppm; R_0805_2012Metric
M_R110: 105k 0.01% 5ppm; R_0805_2012Metric
M_R112: 100k 1%; R_0805_2012Metric
M_R114: 330k 1%; R_0805_2012Metric
M_U1, M_U2, M_U3, M_U4: TLV1824IDR; SOIC-14_3.9x8.7mm_P1.27mm
M_U5: OPA4192ID; SOIC-14_3.9x8.7mm_P1.27mm
M_U6: REF5025EIDR; SOIC-8_3.9x4.9mm_P1.27mm
M_U7: TPS3808G01DBVR; SOT-23-6
M_U8: TPS3808G33DBVR; SOT-23-6
M_U9, M_U10, M_U11, M_U12: SN74LVC08APWR; TSSOP-14_4.4x5mm_P0.65mm

Connections:
/M_rail_monitor/5V_DIG_OV_OK: M_R100.1, M_R101.2, M_U4.13 (4_OUT), M_U10.13 (B)
/M_rail_monitor/5V_DIG_OV_REF: M_C32.1, M_R99.2, M_R100.2, M_U4.11 (4+)
/M_rail_monitor/5V_DIG_OV_REF_BASE: M_R97.2, M_R98.1, M_R99.1
/M_rail_monitor/5V_DIG_OV_SENSE: M_C31.1, M_R95.2, M_R96.1, M_U4.10 (4-)
/M_rail_monitor/5V_DIG_UV_OK: M_R93.1, M_R94.2, M_U4.14 (3_OUT), M_U10.12 (A)
/M_rail_monitor/5V_DIG_UV_REF: M_C30.1, M_R91.2, M_R92.1, M_U4.8 (3-)
/M_rail_monitor/5V_DIG_UV_RT_MID: M_R88.2, M_R89.1
/M_rail_monitor/5V_DIG_UV_SENSE: M_C29.1, M_R89.2, M_R90.1, M_R93.2, M_U4.9 (3+)
/M_rail_monitor/5V_DIG_WINDOW_OK: M_U10.11 (Y), M_U11.13 (B)
/M_rail_monitor/ANALOG_WINDOWS_OK: M_U12.3 (Y), M_U12.9 (A)
/M_rail_monitor/BIAS_OK: M_U11.8 (Y), M_U12.4 (A)
/M_rail_monitor/FIVES_OK: M_U11.11 (Y), M_U12.5 (B)
/M_rail_monitor/HV_OK: M_U11.3 (Y), M_U12.1 (A)
/M_rail_monitor/LOCAL_RAIL_OK: M_R113.2, M_U7.1 (RESET_N), M_U8.1 (RESET_N), M_U12.13 (B)
/M_rail_monitor/LOWV_WINDOWS_OK: M_U12.6 (Y), M_U12.10 (B)
/M_rail_monitor/LV_OK: M_U11.6 (Y), M_U12.2 (B)
/M_rail_monitor/N12_FB: M_C34.2, M_R104.2, M_R105.2, M_U5.6 (N12-)
/M_rail_monitor/N12_INV: M_C34.1, M_R39.1, M_R44.1, M_R105.1, M_U5.7 (N12_OUT)
/M_rail_monitor/N12_OV_OK: M_R49.1, M_R50.2, M_U2.13 (4_OUT), M_U9.13 (B)
/M_rail_monitor/N12_OV_REF: M_C16.1, M_R48.2, M_R49.2, M_U2.11 (4+)
/M_rail_monitor/N12_OV_REF_BASE: M_R46.2, M_R47.1, M_R48.1
/M_rail_monitor/N12_OV_REF_MID: M_R45.2, M_R46.1
/M_rail_monitor/N12_OV_SENSE: M_C15.1, M_R44.2, M_U2.10 (4-)
/M_rail_monitor/N12_UV_OK: M_R42.1, M_R43.2, M_U2.14 (3_OUT), M_U9.12 (A)
/M_rail_monitor/N12_UV_REF: M_C14.1, M_R40.2, M_R41.1, M_U2.8 (3-)
/M_rail_monitor/N12_UV_SENSE: M_C13.1, M_R39.2, M_R42.2, M_U2.9 (3+)
/M_rail_monitor/N12_WINDOW_OK: M_U9.11 (Y), M_U11.5 (B)
/M_rail_monitor/N19_FB: M_C33.2, M_R102.2, M_R103.2, M_U5.2 (N19-)
/M_rail_monitor/N19_INV: M_C33.1, M_R14.1, M_R19.1, M_R103.1, M_U5.1 (N19_OUT)
/M_rail_monitor/N19_OV_OK: M_R23.1, M_R24.2, M_U1.13 (4_OUT), M_U9.5 (B)
/M_rail_monitor/N19_OV_REF: M_C8.1, M_R22.2, M_R23.2, M_U1.11 (4+)
/M_rail_monitor/N19_OV_REF_BASE: M_R20.2, M_R21.1, M_R22.1
/M_rail_monitor/N19_OV_SENSE: M_C7.1, M_R19.2, M_U1.10 (4-)
/M_rail_monitor/N19_UV_OK: M_R17.1, M_R18.2, M_U1.14 (3_OUT), M_U9.4 (A)
/M_rail_monitor/N19_UV_REF: M_C6.1, M_R15.2, M_R16.1, M_U1.8 (3-)
/M_rail_monitor/N19_UV_SENSE: M_C5.1, M_R14.2, M_R17.2, M_U1.9 (3+)
/M_rail_monitor/N19_WINDOW_OK: M_U9.6 (Y), M_U11.2 (B)
/M_rail_monitor/NBIAS_L: M_J3.2, M_R106.1
/M_rail_monitor/NBIAS_L_FB: M_C35.2, M_R106.2, M_R107.2, M_U5.9 (NBIAS_L-)
/M_rail_monitor/NBIAS_L_INV: M_C35.1, M_R51.1, M_R56.1, M_R107.1, M_U5.8 (NBIAS_L_OUT)
/M_rail_monitor/NBIAS_L_OV_OK: M_R60.1, M_R61.2, M_U3.1 (2_OUT), M_U10.2 (B)
/M_rail_monitor/NBIAS_L_OV_REF: M_C20.1, M_R59.2, M_R60.2, M_U3.7 (2+)
/M_rail_monitor/NBIAS_L_OV_REF_BASE: M_R57.2, M_R58.1, M_R59.1
/M_rail_monitor/NBIAS_L_OV_SENSE: M_C19.1, M_R56.2, M_U3.6 (2-)
/M_rail_monitor/NBIAS_L_UV_OK: M_R54.1, M_R55.2, M_U3.2 (1_OUT), M_U10.1 (A)
/M_rail_monitor/NBIAS_L_UV_REF: M_C18.1, M_R52.2, M_R53.1, M_U3.4 (1-)
/M_rail_monitor/NBIAS_L_UV_SENSE: M_C17.1, M_R51.2, M_R54.2, M_U3.5 (1+)
/M_rail_monitor/NBIAS_L_WINDOW_OK: M_U10.3 (Y), M_U11.9 (A)
/M_rail_monitor/NBIAS_R: M_J3.3, M_R108.1
/M_rail_monitor/NBIAS_R_FB: M_C36.2, M_R108.2, M_R109.2, M_U5.13 (NBIAS_R-)
/M_rail_monitor/NBIAS_R_INV: M_C36.1, M_R62.1, M_R67.1, M_R109.1, M_U5.14 (NBIAS_R_OUT)
/M_rail_monitor/NBIAS_R_OV_OK: M_R71.1, M_R72.2, M_U3.13 (4_OUT), M_U10.5 (B)
/M_rail_monitor/NBIAS_R_OV_REF: M_C24.1, M_R70.2, M_R71.2, M_U3.11 (4+)
/M_rail_monitor/NBIAS_R_OV_REF_BASE: M_R68.2, M_R69.1, M_R70.1
/M_rail_monitor/NBIAS_R_OV_SENSE: M_C23.1, M_R67.2, M_U3.10 (4-)
/M_rail_monitor/NBIAS_R_UV_OK: M_R65.1, M_R66.2, M_U3.14 (3_OUT), M_U10.4 (A)
/M_rail_monitor/NBIAS_R_UV_REF: M_C22.1, M_R63.2, M_R64.1, M_U3.8 (3-)
/M_rail_monitor/NBIAS_R_UV_SENSE: M_C21.1, M_R62.2, M_R65.2, M_U3.9 (3+)
/M_rail_monitor/NBIAS_R_WINDOW_OK: M_U10.6 (Y), M_U11.10 (B)
/M_rail_monitor/P12_OV_OK: M_R37.1, M_R38.2, M_U2.1 (2_OUT), M_U9.10 (B)
/M_rail_monitor/P12_OV_REF: M_C12.1, M_R36.2, M_R37.2, M_U2.7 (2+)
/M_rail_monitor/P12_OV_REF_BASE: M_R34.2, M_R35.1, M_R36.1
/M_rail_monitor/P12_OV_REF_MID: M_R33.2, M_R34.1
/M_rail_monitor/P12_OV_SENSE: M_C11.1, M_R31.2, M_R32.1, M_U2.6 (2-)
/M_rail_monitor/P12_UV_OK: M_R29.1, M_R30.2, M_U2.2 (1_OUT), M_U9.9 (A)
/M_rail_monitor/P12_UV_REF: M_C10.1, M_R27.2, M_R28.1, M_U2.4 (1-)
/M_rail_monitor/P12_UV_SENSE: M_C9.1, M_R25.2, M_R26.1, M_R29.2, M_U2.5 (1+)
/M_rail_monitor/P12_WINDOW_OK: M_U9.8 (Y), M_U11.4 (A)
/M_rail_monitor/P19_OV_OK: M_R12.1, M_R13.2, M_U1.1 (2_OUT), M_U9.2 (B)
/M_rail_monitor/P19_OV_REF: M_C4.1, M_R11.2, M_R12.2, M_U1.7 (2+)
/M_rail_monitor/P19_OV_REF_BASE: M_R9.2, M_R10.1, M_R11.1
/M_rail_monitor/P19_OV_SENSE: M_C3.1, M_R7.2, M_R8.1, M_U1.6 (2-)
/M_rail_monitor/P19_UV_OK: M_R5.1, M_R6.2, M_U1.2 (1_OUT), M_U9.1 (A)
/M_rail_monitor/P19_UV_REF: M_C2.1, M_R3.2, M_R4.1, M_U1.4 (1-)
/M_rail_monitor/P19_UV_SENSE: M_C1.1, M_R1.2, M_R2.1, M_R5.2, M_U1.5 (1+)
/M_rail_monitor/P19_WINDOW_OK: M_U9.3 (Y), M_U11.1 (A)
/M_rail_monitor/PRE_ANALOG_OK: M_J4.2, M_R114.1, M_U12.11 (Y)
/M_rail_monitor/REF_2V5: M_C49.1, M_R3.1, M_R9.1, M_R15.1, M_R20.1, M_R27.1, M_R33.1, M_R40.1, M_R45.1, M_R52.1, M_R57.1, M_R63.1, M_R68.1, M_R76.1, M_R83.1, M_R91.1, M_R97.1, M_U6.6 (VOUT)
/M_rail_monitor/STARTUP_CT: M_R112.2, M_U7.4 (CT)
/M_rail_monitor/V3V3_IO: M_C43.1, M_C44.1, M_C45.1, M_C46.1, M_C47.1, M_C48.1, M_C51.1, M_J1.2, M_R6.1, M_R13.1, M_R18.1, M_R24.1, M_R30.1, M_R38.1, M_R43.1, M_R50.1, M_R55.1, M_R61.1, M_R66.1, M_R72.1, M_R79.1, M_R87.1, M_R94.1, M_R101.1, M_R112.1, M_R113.1, M_U7.3 (MR_N), M_U7.6 (VDD), M_U8.3 (MR_N), M_U8.5 (SENSE), M_U8.6 (VDD), M_U9.14 (VCC), M_U10.14 (VCC), M_U11.14 (VCC), M_U12.14 (VCC)
/M_rail_monitor/V5_COARSE_SENSE: M_R110.2, M_R111.1, M_U7.5 (SENSE)
/M_rail_monitor/V5_REG_OV_OK: M_R86.1, M_R87.2, M_U4.1 (2_OUT), M_U10.10 (B)
/M_rail_monitor/V5_REG_OV_REF: M_C28.1, M_R85.2, M_R86.2, M_U4.7 (2+)
/M_rail_monitor/V5_REG_OV_REF_BASE: M_R83.2, M_R84.1, M_R85.1
/M_rail_monitor/V5_REG_OV_RT_MID: M_R80.2, M_R81.1
/M_rail_monitor/V5_REG_OV_SENSE: M_C27.1, M_R81.2, M_R82.1, M_U4.6 (2-)
/M_rail_monitor/V5_REG_UV_OK: M_R78.1, M_R79.2, M_U4.2 (1_OUT), M_U10.9 (A)
/M_rail_monitor/V5_REG_UV_REF: M_C26.1, M_R76.2, M_R77.1, M_U4.4 (1-)
/M_rail_monitor/V5_REG_UV_RT_MID: M_R73.2, M_R74.1
/M_rail_monitor/V5_REG_UV_SENSE: M_C25.1, M_R74.2, M_R75.1, M_R78.2, M_U4.5 (1+)
/M_rail_monitor/V5_REG_WINDOW_OK: M_U10.8 (Y), M_U11.12 (A)
/M_rail_monitor/WINDOWS_OK: M_U12.8 (Y), M_U12.12 (A)
PWR_5V_DIG: M_J1.1, M_R88.1, M_R95.1; also elsewhere on the board
PWR_AGND: M_C1.2, M_C2.2, M_C3.2, M_C4.2, M_C5.2, M_C6.2, M_C7.2, M_C8.2, M_C9.2, M_C10.2, M_C11.2, M_C12.2, M_C13.2, M_C14.2, M_C15.2, M_C16.2, M_C17.2, M_C18.2, M_C19.2, M_C20.2, M_C21.2, M_C22.2, M_C23.2, M_C24.2, M_C25.2, M_C26.2, M_C27.2, M_C28.2, M_C29.2, M_C30.2, M_C31.2, M_C32.2, M_C37.2, M_C38.2, M_C39.2, M_C40.2, M_C41.2, M_C42.2, M_C43.2, M_C44.2, M_C45.2, M_C46.2, M_C47.2, M_C48.2, M_C49.2, M_C50.2, M_C51.2, M_J1.3, M_J2.2, M_J3.1, M_J4.1, M_R2.2, M_R4.2, M_R8.2, M_R10.2, M_R16.2, M_R21.2, M_R26.2, M_R28.2, M_R32.2, M_R35.2, M_R41.2, M_R47.2, M_R53.2, M_R58.2, M_R64.2, M_R69.2, M_R75.2, M_R77.2, M_R82.2, M_R84.2, M_R90.2, M_R92.2, M_R96.2, M_R98.2, M_R111.2, M_R114.2, M_U1.12 (V-), M_U2.12 (V-), M_U3.12 (V-), M_U4.12 (V-), M_U5.3 (N19+), M_U5.5 (N12+), M_U5.10 (NBIAS_L+), M_U5.11 (V-), M_U5.12 (NBIAS_R+), M_U6.4 (GND), M_U7.2 (GND), M_U8.2 (GND), M_U9.7 (GND), M_U10.7 (GND), M_U11.7 (GND), M_U12.7 (GND); also elsewhere on the board
PWR_N12: M_J2.5, M_R104.1; also elsewhere on the board
PWR_N19: M_J2.3, M_R102.1; also elsewhere on the board
PWR_P12: M_J2.4, M_R25.1, M_R31.1; also elsewhere on the board
PWR_P19: M_J2.1, M_R1.1, M_R7.1; also elsewhere on the board
PWR_V5_REG: M_C37.1, M_C38.1, M_C39.1, M_C40.1, M_C41.1, M_C42.1, M_C50.1, M_J2.6, M_R73.1, M_R80.1, M_R110.1, M_U1.3 (V+), M_U2.3 (V+), M_U3.3 (V+), M_U4.3 (V+), M_U5.4 (V+), M_U6.1 (EN), M_U6.2 (VIN); also elsewhere on the board

Notes on the sheet:
E13: eight independent UV/OV windows + coarse5V/3.3V guard. PRE_ANALOG_OK is generated in hardware, independent of MCU firmware.
Monitor only: no power generation, rail disconnect/clamp, transient-fault or fabrication approval. Precision/offset/reference allocations require qualification.
Each open-drain comparator has its own pull-up and hysteresis. Do NOT wire comparator outputs together; use the shown AND tree.
Coarse guard holds qualification low while reference/sense amplifiers start. E09/E11/F02 retain settling and fresh-permit requirements.
Main-rail fault envelope extends to +/-3.2% with a conditional headroom review; normal generation remains +/-1%. Analog5V generation must be tighter than its4.90..5.10V accepted envelope.
