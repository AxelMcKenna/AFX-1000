# Repository AxelMcKenna/AFX-1000 (continued)

## KiCad design hardware/fabrication/staging/two-board-power-digital-reference-02/power_protection.kicad_pcb (continued)

Schematic: N_negative_startup_physical.kicad_sch, Standalone RMX - negative_startup_physical

Parts:
N_C1: 56nF50V C0G5% C1206C563J5GACTU - COMPLETE10% RECE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; PROPOSED_KEMET1206_LevelB
N_C2: 33nF50V C0G5% C1206C333J5GACTU - COMPLETE10% RECE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; PROPOSED_KEMET1206_LevelB
N_C3, N_C12, N_C39, N_C55, N_C56, N_C57, N_C58, N_C59, N_C60, N_C61, N_C62, N_C63, N_C64, N_C65, N_C66, N_C67, N_C68, N_C69, N_C70, N_C71, N_C72, N_C73, N_C74, N_C75, N_C76, N_C77, N_C78, N_C79, N_C80, N_C81, N_C82, N_C83, N_C84, N_C85, N_C86, N_C87, N_C88: 100nF 50V X7R10% C0603C104K5RACTU - bypass effect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; PROPOSED_KEMET0603_LevelB
N_C4, N_C31: 10uF 25V X7R MODULE INPUT FILTER/EFFECTIVE/INRUSH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; Capacitor_SMD__C_1206_3216Metric
N_C5, N_C32: 1uF 50V X7R MODULE OUTPUT FILTER/EFFECTIVE HOLD; Capacitor_SMD__C_1206_3216Metric
N_C6, N_C33: 1uF 25V X7R LTC4261 local VIN effective HOLD; Capacitor_SMD__C_1206_3216Metric
N_C7, N_C9, N_C11, N_C13, N_C34, N_C36, N_C38, N_C40: 100nF 25V C0G C1206C104J3GACTU; PROPOSED_KEMET1206_LevelB
N_C8, N_C10, N_C35, N_C37: 10nF 50V C0G COMPLETE10% TIMING RECEIVING; PROPOSED_KEMET1206_LevelB
N_C14, N_C15, N_C16, N_C17, N_C18, N_C19, N_C20, N_C21, N_C22, N_C23, N_C24, N_C25, N_C41, N_C42, N_C43, N_C44, N_C45, N_C46, N_C47, N_C48, N_C49: 100nF 50V C0G C1210C104J5GACTU - COMPLETE10% RAMP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; PROPOSED_KEMET1210_LevelB
N_C26, N_C27, N_C50, N_C51: 2.2uF 63V PET5% MKS2C042201K00JSSD - COMPLETE10% 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; Capacitor_THT__C_Rect_L7.2mm_W7.2mm_P5.00mm_FKS2_FKP2_MKS2_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
N_C28, N_C30, N_C52, N_C54: 47nF 50V C0G C1206C473J5GACTU; PROPOSED_KEMET1206_LevelB
N_C29, N_C53: 100nF 50V C0G C1210C104J5GACTU; PROPOSED_KEMET1210_LevelB
N_C89, N_C90, N_C91, N_C93, N_C94, N_C96: 100nF50V X7R10% C0603C104K5RACTU - EFFECTIVE/PDN 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; PROPOSED_KEMET0603_LevelB
N_C92, N_C95: 47nF50V C0G5% C1206C473J5GACTU - COMPLETE6% RECEI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; PROPOSED_KEMET1206_LevelB
N_C97, N_C98: 100nF25V C0G5% C1206C104J3GACTU - COMPLETE6% CT /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; PROPOSED_KEMET1206_LevelB
N_C99: 100nF25V C0G5% C1206C104J3GACTU - COMPLETE6% UVRE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; PROPOSED_KEMET1206_LevelB
N_C100: 100nF50V X7R10% C0603C104K5RACTU - LOCAL_BYPASS_E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; PROPOSED_KEMET0603_LevelB
N_J1: NEW NF03C CONTROL/KELVIN INTERFACE - physical con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; NC265_JST_PHD_B30B-PHDSS_2x15_P2.00mm_Vertical
N_J2: N19 NEW FORCE IN/OUT - connector and harness unse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; NC265_NC265_Force2_18AWG_P5_Drill2p2_Land3p8
N_J3: N19 E28 BANK GATE/COMMON CLAMP - physical interfa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; NC265_JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
N_J4: N12 NEW FORCE IN/OUT - connector and harness unse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; NC265_NC265_Force2_18AWG_P5_Drill2p2_Land3p8
N_J5: N12 E28 BANK GATE/COMMON CLAMP - physical interfa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; NC265_JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
N_J6: NEW MODULE INPUT ONLY - keyed JST XH2 receiving c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; NC265_JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
N_Q1, N_Q2: CSD19536KTT; Package_TO_SOT_SMD__TO-263-2
N_R1, N_R2, N_R8, N_R9: 10k; PROPOSED_TNPW0805_IPC28950
N_R3, N_R10: 205000ohm 0.1% TNPW0805205KBEEA - COMPLETE3% RECE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; PROPOSED_TNPW0805_IPC28950
N_R4, N_R11: 499ohm 0.1% TNPW0805499RBEEA - COMPLETE3% RECEIVI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; PROPOSED_TNPW0805_IPC28950
N_R5, N_R12, N_R95, N_R98, N_R99: 10000ohm 0.1% TNPW080510K0BEEA - COMPLETE3% RECEI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; PROPOSED_TNPW0805_IPC28950
N_R6, N_R7, N_R13, N_R14: 220ohm COMPLETE +/-3% RECEIVING; PROPOSED_TNPW0805_IPC28950
N_R15, N_R16, N_R17, N_R18, N_R19, N_R20, N_R21, N_R22: 47k 3% TOTAL RECEIVING; PROPOSED_TNPW0805_IPC28950
N_R23: 160000ohm COMPLETE0.1% RECEIVING; PROPOSED_TNPU0805_IPC28950
N_R24, N_R41, N_R63, N_R65, N_R80, N_R82: 10k COMPLETE0.1% RECEIVING; PROPOSED_TNPU0805_IPC28950
N_R25, N_R49: 8660ohm COMPLETE0.1% RECEIVING; PROPOSED_TNPU0805_IPC28950
N_R26, N_R50: 35.7ohm COMPLETE0.1% RECEIVING; PROPOSED_TNPU0603_IPC28950
N_R27, N_R31, N_R35, N_R44, N_R47, N_R51: 100k COMPLETE0.1% RECEIVING; PROPOSED_TNPU0805_IPC28950
N_R28, N_R32, N_R36, N_R37, N_R38, N_R39, N_R45, N_R48, N_R52, N_R53, N_R54, N_R55, N_R59, N_R76: 10k COMPLETE3% RECEIVING; PROPOSED_TNPW0805_IPC28950
N_R29, N_R46: 2000ohm COMPLETE0.1% RECEIVING; PROPOSED_TNPU0805_IPC28950
N_R30: 40.2ohm COMPLETE0.1% RECEIVING; PROPOSED_TNPU0603_IPC28950
N_R33: 6040ohm COMPLETE0.1% RECEIVING; PROPOSED_TNPU0805_IPC28950
N_R34: 75ohm COMPLETE0.1% RECEIVING; PROPOSED_TNPU0603_IPC28950
N_R40: 102000ohm COMPLETE0.1% RECEIVING; PROPOSED_TNPU0805_IPC28950
N_R42: 10700ohm COMPLETE0.1% RECEIVING; PROPOSED_TNPU0805_IPC28950
N_R43: 169ohm COMPLETE0.1% RECEIVING; PROPOSED_TNPU0805_IPC28950
N_R56, N_R57, N_R73, N_R74: 402ohm 1% CRCW2010402RFKEF - COMPLETE3% RECEIVING; PROPOSED_CRCW2010_reflow20035
N_R58, N_R60, N_R61, N_R66, N_R67, N_R68, N_R75, N_R77, N_R78, N_R83, N_R84, N_R85: 47k COMPLETE3% RECEIVING; PROPOSED_TNPW0805_IPC28950
N_R62, N_R79: 30.4k COMPLETE0.1% RECEIVING; PROPOSED_TNPU0805_IPC28950
N_R64, N_R81: 78.7k COMPLETE0.1% RECEIVING; PROPOSED_TNPU0805_IPC28950
N_R69: 0.33ohm COMPLETE5% SHUNT RECEIVING; PROPOSED_WSL2512_7m_to500m
N_R70, N_R87: 10ohm COMPLETE3% RECEIVING; PROPOSED_TNPW0805_IPC28950
N_R71, N_R88: 1M; PROPOSED_TNPW0805_IPC28950
N_R72: 27ohm COMPLETE3% RECEIVING; PROPOSED_TNPW0805_IPC28950
N_R86: 0.12ohm COMPLETE5% SHUNT RECEIVING; PROPOSED_WSL2512_7m_to500m
N_R89: 39ohm COMPLETE3% RECEIVING; PROPOSED_TNPW0805_IPC28950
N_R90, N_R91: 10k0.1% TNPW080510K0BEEA - COMPLETE3% RECEIVING; PROPOSED_TNPW0805_IPC28950
N_R92: 11300ohm 0.02% 2ppm TNPU080511K3HWEN00 - COMPLETE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; PROPOSED_TNPW0805_IPC28950
N_R93: 49.9ohm 0.1% TNPW080549R9BEEA - COMPLETE0.7% TRIM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; PROPOSED_TNPW0805_IPC28950
N_R94: 10000ohm 0.02% 2ppm TNPU080510K0HWEN00 - COMPLETE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; PROPOSED_TNPW0805_IPC28950
N_R96: 47000ohm 0.1% TNPW080547K0BEEA - COMPLETE3% RECEI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; PROPOSED_TNPW0805_IPC28950
N_R97: 680ohm 0.1% TNPW1206680RBEEA - COMPLETE3% RECEIVI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; PROPOSED_TNPW1206_IPC28950
N_U1, N_U2, N_U7, N_U8: SN74AUP1G74DCUR; NF05R_Manufacturer__TI_DCU0008A
N_U3, N_U9: TPS3431SDRBR; TI_DRB0008A_TPS3431
N_U4, N_U10: SN74LVC1G06DBVR; Package_TO_SOT_SMD__SOT-23-5
N_U5, N_U6, N_U11, N_U12: TLP4590AF(F; Package_DIP__DIP-6_W10.16mm
N_U13: OPA2333AID; Package_SO__SOIC-8_3.9x4.9mm_P1.27mm
N_U14: TLV1822DR; Package_SO__SOIC-8_3.9x4.9mm_P1.27mm
N_U15: TLV1824DR; Package_SO__SOIC-14_3.9x8.7mm_P1.27mm
N_U16, N_U27: SN74LVC2T45DCUR; NF05R_Manufacturer__TI_DCU0008A
N_U17, N_U22: TMR 1-1215; Converter_DCDC__Converter_DCDC_TRACO_TMR-1-xxxx_Single_THT
N_U18, N_U23: LTC4261IGN#PBF; Package_SO__SSOP-28_3.9x9.9mm_P0.635mm
N_U19, N_U24: ISO7721FDR; Package_SO__SOIC-8_3.9x4.9mm_P1.27mm
N_U20, N_U21, N_U25, N_U26, N_U52, N_U54, N_U56: TPS389001DSET; Package_SON__WSON-6_1.5x1.5mm_P0.5mm
N_U28, N_U30, N_U53, N_U55: SN74LVC1G17DCKR; NF05R_Manufacturer__TI_DCK0005A
N_U29, N_U31, N_U32, N_U33, N_U34, N_U49: SN74AUP2G14DCKR; NF05R_Manufacturer__TI_DCK0006A
N_U35, N_U36, N_U37, N_U38, N_U39, N_U40, N_U41, N_U42, N_U43, N_U44, N_U51: SN74HCS08PWR; Package_SO__TSSOP-14_4.4x5mm_P0.65mm
N_U45, N_U46: SN74HCS32PWR; Package_SO__TSSOP-14_4.4x5mm_P0.65mm
N_U47, N_U48: SN74HCS14PWR; Package_SO__TSSOP-14_4.4x5mm_P0.65mm
N_U50: SN74HCS02PWR; Package_SO__TSSOP-14_4.4x5mm_P0.65mm
N_U57: TPS22919DCKR; NF05R_Manufacturer__TI_DCK0006A
N_U58: SN74LVC1G14DCKR; NF05R_Manufacturer__TI_DCK0005A

Connections:
/N_negative_startup_protection/ABS_AUX_CT: N_C99.1, N_U56.5 (CT)
/N_negative_startup_protection/ABS_AUX_FAULT: N_J1.7 (ABS_AUX_FAULT_MONITOR_OUTPUT_ONLY), N_R17.1, N_U48.13 (6A), N_U58.4 (Y)
/N_negative_startup_protection/ABS_AUX_READY: N_U48.12 (6Y), N_U51.13 (4B)
/N_negative_startup_protection/ABS_AUX_SENSE: N_R93.2, N_R94.1, N_U56.1 (SENSE)
/N_negative_startup_protection/ABS_AUX_TOP_TRIM: N_R92.2, N_R93.1
/N_negative_startup_protection/CLAMP_LED_SUPPLY: N_C98.1, N_R4.1, N_R11.1, N_R97.1, N_U57.6 (VOUT)
/N_negative_startup_protection/CLAMP_SUPPLY_ENABLE: N_R95.2, N_R96.1, N_U56.6 (RESET_N), N_U57.3 (ON), N_U58.2 (A)
/N_negative_startup_protection/E28_COMBINED_FAULT_REQUEST_HCS: N_U34.1 (1A), N_U46.6 (2Y)
/N_negative_startup_protection/GLOBAL_VALID: N_U35.3 (1Y), N_U35.4 (2A), N_U35.5 (2B), N_U35.12 (4A), N_U37.4 (2A), N_U38.5 (2B), N_U38.13 (4B), N_U40.12 (4A), N_U41.13 (4B), N_U48.11 (5A), N_U51.1 (1A), N_U51.4 (2A)
/N_negative_startup_protection/N12_ARM_CONDITIONED: N_J1.24 (N12_ARM_MONITOR_OUTPUT_ONLY), N_R20.1, N_U30.4 (Y), N_U39.1 (1A), N_U40.13 (4B), N_U41.12 (4A), N_U54.1 (SENSE)
/N_negative_startup_protection/N12_ARM_Q: N_U30.2 (A), N_U50.10 (3Y), N_U50.12 (4B)
/N_negative_startup_protection/N12_ARM_QBAR: N_U50.9 (3B), N_U50.13 (4Y)
/N_negative_startup_protection/N12_ARM_SET: N_U50.11 (4A), N_U51.8 (3Y)
/N_negative_startup_protection/N12_BANK_CLAMP_GATE: N_R14.2, N_U12.4 (D1)
/N_negative_startup_protection/N12_BIAS_CT: N_C37.1, N_U25.5 (CT)
/N_negative_startup_protection/N12_BIAS_HOST5: N_R84.1, N_U24.6 (OUTB), N_U27.3 (A2)
/N_negative_startup_protection/N12_BIAS_RESET_N: N_R83.2, N_U24.3 (INB), N_U25.6 (RESET_N), N_U26.6 (RESET_N)
/N_negative_startup_protection/N12_BIAS_SENSE: N_R79.2, N_R80.1, N_U25.1 (SENSE)
/N_negative_startup_protection/N12_BIAS_VALID: N_J1.17 (N12_BIAS_VALID), N_R85.1, N_U27.6 (B2), N_U43.13 (4B)
/N_negative_startup_protection/N12_CG_SERIES: N_C52.1, N_R87.2
/N_negative_startup_protection/N12_CLAMPS_RELEASE: N_J1.28 (N12_CLAMPS_RELEASE), N_R10.1, N_U10.2 (A), N_U33.4 (2Y)
/N_negative_startup_protection/N12_CLAMPS_RELEASE_BUFFER_MID: N_U33.3 (2A), N_U33.6 (1Y)
/N_negative_startup_protection/N12_CLAMPS_RELEASE_HCS: N_U33.1 (1A), N_U42.3 (1Y)
/N_negative_startup_protection/N12_CLAMP_LED_A: N_R11.2, N_R12.1, N_U11.1 (LED_A)
/N_negative_startup_protection/N12_CLAMP_LED_K: N_R99.2, N_U10.4 (Y), N_U12.2 (LED_K)
/N_negative_startup_protection/N12_CLAMP_LED_MID: N_R12.2, N_R99.1, N_U11.2 (LED_K), N_U12.1 (LED_A)
/N_negative_startup_protection/N12_COMPLETE: N_J1.27 (N12_COMPLETE), N_U8.5 (Q), N_U39.12 (4A), N_U44.12 (4A)
/N_negative_startup_protection/N12_COMPLETE_CLK: N_U8.1 (CLK), N_U41.8 (3Y)
/N_negative_startup_protection/N12_COMPLETE_CLR_N: N_U8.6 (CLR_N), N_U41.11 (4Y)
/N_negative_startup_protection/N12_CONTROLLER_ON: N_R77.1, N_U23.2 (ON), N_U24.2 (OUTA)
/N_negative_startup_protection/N12_CR_TOP: N_C41.1, N_C42.1, N_C43.1, N_C44.1, N_C45.1, N_C46.1, N_C47.1, N_C48.1, N_C49.1, N_R89.2
/N_negative_startup_protection/N12_CWD: N_C2.1, N_U9.2 (CWD)
/N_negative_startup_protection/N12_DRAIN_SENSE: N_R88.2, N_U23.16 (DRAIN)
/N_negative_startup_protection/N12_F0: N_U45.8 (3Y), N_U45.12 (4A)
/N_negative_startup_protection/N12_FAULT_REQUEST: N_J1.26 (N12_FAULT_REQUEST), N_U45.11 (4Y), N_U46.2 (1B)
/N_negative_startup_protection/N12_FEED_MID: N_R73.2, N_R74.1
/N_negative_startup_protection/N12_F_OUTPUT: N_U39.11 (4Y), N_U45.13 (4B)
/N_negative_startup_protection/N12_F_SOURCE: N_U39.3 (1Y), N_U45.9 (3A)
/N_negative_startup_protection/N12_F_TIMEOUT: N_U39.8 (3Y), N_U45.10 (3B)
/N_negative_startup_protection/N12_F_WD_ARM: N_U39.6 (2Y), N_U39.9 (3A)
/N_negative_startup_protection/N12_INTVCC: N_C34.1, N_C36.1, N_C38.1, N_C40.1, N_R79.1, N_R83.1, N_U23.5 (SDAI), N_U23.6 (SCL), N_U23.7 (INTVCC), N_U23.8 (UVL), N_U23.9 (UVH), N_U23.22 (FLTIN), N_U24.1 (VCC1), N_U25.3 (MR_N), N_U25.4 (VDD), N_U26.3 (MR_N), N_U26.4 (VDD)
/N_negative_startup_protection/N12_ISO24: N_C32.1, N_R73.1, N_U22.4 (+VOUT)
/N_negative_startup_protection/N12_NOT_COMPLETE: N_U8.3 (NOT_Q), N_U9.5 (SET1)
/N_negative_startup_protection/N12_NOT_PERMIT: N_U7.3 (NOT_Q), N_U9.6 (WDI)
/N_negative_startup_protection/N12_NOT_READY: N_U39.13 (4B), N_U47.10 (5Y)
/N_negative_startup_protection/N12_NOT_SAFE: N_U39.2 (1B), N_U47.8 (4Y)
/N_negative_startup_protection/N12_NOT_WDO: N_U39.10 (3B), N_U47.12 (6Y)
/N_negative_startup_protection/N12_OUTPUT_OV_GOOD: N_R55.2, N_U15.13 (OUT4), N_U43.10 (3B), N_U44.2 (1B)
/N_negative_startup_protection/N12_OUTPUT_QUALIFIED: N_U44.11 (4Y), N_U48.5 (3A)
/N_negative_startup_protection/N12_OUTPUT_UV_GOOD: N_R54.2, N_U15.14 (OUT3), N_U44.1 (1A)
/N_negative_startup_protection/N12_OUT_INV: N_R41.1, N_R45.1, N_R48.1, N_U13.7 (OUTB)
/N_negative_startup_protection/N12_OUT_OV_REF: N_R46.2, N_R47.1, N_U15.11 (IN4+)
/N_negative_startup_protection/N12_OUT_OV_SENSE: N_R48.2, N_U15.10 (IN4-)
/N_negative_startup_protection/N12_OUT_SUM: N_R40.2, N_R41.2, N_U13.6 (INB-)
/N_negative_startup_protection/N12_OUT_UV_REF: N_R43.2, N_R44.1, N_U15.8 (IN3-)
/N_negative_startup_protection/N12_OUT_UV_RMID: N_R42.2, N_R43.1
/N_negative_startup_protection/N12_OUT_UV_SENSE: N_R45.2, N_U15.9 (IN3+)
/N_negative_startup_protection/N12_PASS_CLAMP_GATE: N_R13.2, N_U11.4 (D1)
/N_negative_startup_protection/N12_PASS_GATE: N_Q2.1 (G), N_R13.1, N_R87.1, N_U23.15 (GATE)
/N_negative_startup_protection/N12_PASS_SOURCE: N_Q2.3 (S), N_R86.2, N_U11.6 (D2), N_U23.14 (SENSE)
/N_negative_startup_protection/N12_PCLR0: N_U40.11 (4Y), N_U41.1 (1A), N_U42.1 (1A)
/N_negative_startup_protection/N12_PCLR1: N_U41.3 (1Y), N_U41.4 (2A)
/N_negative_startup_protection/N12_PERMIT: N_U7.5 (Q), N_U16.3 (A2), N_U41.9 (3A)
/N_negative_startup_protection/N12_PERMIT_CLR_N: N_U7.6 (CLR_N), N_U41.6 (2Y)
/N_negative_startup_protection/N12_PERMIT_D: N_U7.2 (D), N_U40.8 (3Y), N_U51.10 (3B)
/N_negative_startup_protection/N12_RAMP: N_C50.1, N_C51.1, N_R89.1, N_U23.18 (RAMP)
/N_negative_startup_protection/N12_READY: N_U41.10 (3B), N_U44.3 (1Y), N_U44.13 (4B), N_U47.11 (5A)
/N_negative_startup_protection/N12_RUN_HOST5: N_R78.1, N_U16.6 (B2), N_U24.7 (INA)
/N_negative_startup_protection/N12_SAFE: N_U40.5 (2B), N_U41.5 (2B), N_U43.11 (4Y), N_U47.9 (4A)
/N_negative_startup_protection/N12_SOURCE_SAFE0: N_U43.6 (2Y), N_U43.9 (3A)
/N_negative_startup_protection/N12_SOURCE_SAFE1: N_U43.8 (3Y), N_U43.12 (4A)
/N_negative_startup_protection/N12_SOURCE_UV_GOOD: N_R53.2, N_U14.7 (OUT2), N_U43.4 (2A)
/N_negative_startup_protection/N12_SOURCE_UV_REF: N_R50.2, N_R51.1, N_U14.6 (IN2-)
/N_negative_startup_protection/N12_SOURCE_UV_RMID: N_R49.2, N_R50.1
/N_negative_startup_protection/N12_SOURCE_UV_SENSE: N_R52.2, N_U14.5 (IN2+)
/N_negative_startup_protection/N12_SS: N_C53.1, N_U23.19 (SS)
/N_negative_startup_protection/N12_STAGE_ENABLED: N_U38.12 (4A), N_U39.4 (2A), N_U51.6 (2Y), N_U51.9 (3A)
/N_negative_startup_protection/N12_START: N_J1.25 (N12_START_MONITOR_OUTPUT_ONLY), N_R21.1, N_U31.1 (1A), N_U55.4 (Y)
/N_negative_startup_protection/N12_START_ARMED: N_U40.3 (1Y), N_U40.4 (2A)
/N_negative_startup_protection/N12_START_CONDITIONED: N_U7.1 (CLK), N_U31.4 (2Y)
/N_negative_startup_protection/N12_START_CONDITIONED_BUFFER_MID: N_U31.3 (2A), N_U31.6 (1Y)
/N_negative_startup_protection/N12_START_CT: N_C95.1, N_U54.5 (CT)
/N_negative_startup_protection/N12_START_DELAY_N: N_R91.2, N_U54.6 (RESET_N), N_U55.2 (A)
/N_negative_startup_protection/N12_START_SAFE: N_U40.6 (2Y), N_U40.9 (3A)
/N_negative_startup_protection/N12_TMR: N_C54.1, N_U23.20 (TMR)
/N_negative_startup_protection/N12_VIN: N_C33.1, N_R74.2, N_R75.1, N_R81.1, N_U23.21 (VIN)
/N_negative_startup_protection/N12_VIN_VALID_CT: N_C35.1, N_U26.5 (CT)
/N_negative_startup_protection/N12_VIN_VALID_SENSE: N_R81.2, N_R82.1, N_U26.1 (SENSE)
/N_negative_startup_protection/N12_WDO: N_R8.2, N_U9.7 (WDO), N_U40.2 (1B), N_U47.13 (6A)
/N_negative_startup_protection/N12_WD_ARMED: N_R9.2, N_U9.8 (ENOUT), N_U39.5 (2B), N_U40.1 (1A)
/N_negative_startup_protection/N12_WD_ENABLE: N_U9.3 (EN), N_U38.11 (4Y)
/N_negative_startup_protection/N19_ARM_CONDITIONED: N_J1.18 (N19_ARM_MONITOR_OUTPUT_ONLY), N_R18.1, N_U28.4 (Y), N_U35.9 (3A), N_U37.5 (2B), N_U38.4 (2A), N_U52.1 (SENSE)
/N_negative_startup_protection/N19_ARM_Q: N_U28.2 (A), N_U50.1 (1Y), N_U50.6 (2B)
/N_negative_startup_protection/N19_ARM_QBAR: N_U50.3 (1B), N_U50.4 (2Y)
/N_negative_startup_protection/N19_ARM_SET: N_U50.5 (2A), N_U51.3 (1Y)
/N_negative_startup_protection/N19_BANK_CLAMP_GATE: N_R7.2, N_U6.4 (D1)
/N_negative_startup_protection/N19_BIAS_CT: N_C10.1, N_U20.5 (CT)
/N_negative_startup_protection/N19_BIAS_HOST5: N_R67.1, N_U19.6 (OUTB), N_U27.2 (A1)
/N_negative_startup_protection/N19_BIAS_RESET_N: N_R66.2, N_U19.3 (INB), N_U20.6 (RESET_N), N_U21.6 (RESET_N)
/N_negative_startup_protection/N19_BIAS_SENSE: N_R62.2, N_R63.1, N_U20.1 (SENSE)
/N_negative_startup_protection/N19_BIAS_VALID: N_J1.16 (N19_BIAS_VALID), N_R68.1, N_U27.7 (B1), N_U42.13 (4B)
/N_negative_startup_protection/N19_CG_SERIES: N_C28.1, N_R70.2
/N_negative_startup_protection/N19_CLAMPS_RELEASE: N_J1.22 (N19_CLAMPS_RELEASE), N_R3.1, N_U4.2 (A), N_U32.4 (2Y)
/N_negative_startup_protection/N19_CLAMPS_RELEASE_BUFFER_MID: N_U32.3 (2A), N_U32.6 (1Y)
/N_negative_startup_protection/N19_CLAMPS_RELEASE_HCS: N_U32.1 (1A), N_U38.8 (3Y)
/N_negative_startup_protection/N19_CLAMP_LED_A: N_R4.2, N_R5.1, N_U5.1 (LED_A)
/N_negative_startup_protection/N19_CLAMP_LED_K: N_R98.2, N_U4.4 (Y), N_U6.2 (LED_K)
/N_negative_startup_protection/N19_CLAMP_LED_MID: N_R5.2, N_R98.1, N_U5.2 (LED_K), N_U6.1 (LED_A)
/N_negative_startup_protection/N19_COMPLETE: N_J1.21 (N19_COMPLETE), N_U2.5 (Q), N_U36.4 (2A), N_U44.9 (3A)
/N_negative_startup_protection/N19_COMPLETE_CLK: N_U2.1 (CLK), N_U38.3 (1Y)
/N_negative_startup_protection/N19_COMPLETE_CLR_N: N_U2.6 (CLR_N), N_U38.6 (2Y)
/N_negative_startup_protection/N19_CONTROLLER_ON: N_R60.1, N_U18.2 (ON), N_U19.2 (OUTA)
/N_negative_startup_protection/N19_CR_TOP: N_C14.1, N_C15.1, N_C16.1, N_C17.1, N_C18.1, N_C19.1, N_C20.1, N_C21.1, N_C22.1, N_C23.1, N_C24.1, N_C25.1, N_R72.2
/N_negative_startup_protection/N19_CWD: N_C1.1, N_U3.2 (CWD)
/N_negative_startup_protection/N19_DRAIN_SENSE: N_R71.2, N_U18.16 (DRAIN)
/N_negative_startup_protection/N19_F0: N_U45.3 (1Y), N_U45.4 (2A)
/N_negative_startup_protection/N19_FAULT_REQUEST: N_J1.20 (N19_FAULT_REQUEST), N_U45.6 (2Y), N_U46.1 (1A)
/N_negative_startup_protection/N19_FEED_MID: N_R56.2, N_R57.1
/N_negative_startup_protection/N19_F_OUTPUT: N_U36.6 (2Y), N_U45.5 (2B)
/N_negative_startup_protection/N19_F_SOURCE: N_U35.8 (3Y), N_U45.1 (1A)
/N_negative_startup_protection/N19_F_TIMEOUT: N_U36.3 (1Y), N_U45.2 (1B)
/N_negative_startup_protection/N19_F_WD_ARM: N_U35.11 (4Y), N_U36.1 (1A)
/N_negative_startup_protection/N19_INTVCC: N_C7.1, N_C9.1, N_C11.1, N_C13.1, N_R62.1, N_R66.1, N_U18.5 (SDAI), N_U18.6 (SCL), N_U18.7 (INTVCC), N_U18.8 (UVL), N_U18.9 (UVH), N_U18.22 (FLTIN), N_U19.1 (VCC1), N_U20.3 (MR_N), N_U20.4 (VDD), N_U21.3 (MR_N), N_U21.4 (VDD)
/N_negative_startup_protection/N19_ISO24: N_C5.1, N_R56.1, N_U17.4 (+VOUT)
/N_negative_startup_protection/N19_NOT_COMPLETE: N_U2.3 (NOT_Q), N_U3.5 (SET1)
/N_negative_startup_protection/N19_NOT_PERMIT: N_U1.3 (NOT_Q), N_U3.6 (WDI)
/N_negative_startup_protection/N19_NOT_READY: N_U36.5 (2B), N_U47.4 (2Y)
/N_negative_startup_protection/N19_NOT_SAFE: N_U35.10 (3B), N_U47.2 (1Y)
/N_negative_startup_protection/N19_NOT_WDO: N_U36.2 (1B), N_U47.6 (3Y)
/N_negative_startup_protection/N19_OUTPUT_OV_GOOD: N_R39.2, N_U15.1 (OUT2), N_U42.10 (3B), N_U43.2 (1B)
/N_negative_startup_protection/N19_OUTPUT_QUALIFIED: N_U44.8 (3Y), N_U48.3 (2A), N_U51.5 (2B)
/N_negative_startup_protection/N19_OUTPUT_UV_GOOD: N_R38.2, N_U15.2 (OUT1), N_U43.1 (1A)
/N_negative_startup_protection/N19_OUT_INV: N_R24.1, N_R28.1, N_R32.1, N_U13.1 (OUTA)
/N_negative_startup_protection/N19_OUT_OV_REF: N_R30.2, N_R31.1, N_U15.7 (IN2+)
/N_negative_startup_protection/N19_OUT_OV_RMID: N_R29.2, N_R30.1
/N_negative_startup_protection/N19_OUT_OV_SENSE: N_R32.2, N_U15.6 (IN2-)
/N_negative_startup_protection/N19_OUT_SUM: N_R23.2, N_R24.2, N_U13.2 (INA-)
/N_negative_startup_protection/N19_OUT_UV_REF: N_R26.2, N_R27.1, N_U15.4 (IN1-)
/N_negative_startup_protection/N19_OUT_UV_RMID: N_R25.2, N_R26.1
/N_negative_startup_protection/N19_OUT_UV_SENSE: N_R28.2, N_U15.5 (IN1+)
/N_negative_startup_protection/N19_PASS_CLAMP_GATE: N_R6.2, N_U5.4 (D1)
/N_negative_startup_protection/N19_PASS_GATE: N_Q1.1 (G), N_R6.1, N_R70.1, N_U18.15 (GATE)
/N_negative_startup_protection/N19_PASS_SOURCE: N_Q1.3 (S), N_R69.2, N_U5.6 (D2), N_U18.14 (SENSE)
/N_negative_startup_protection/N19_PCLR0: N_U37.6 (2Y), N_U37.9 (3A), N_U38.9 (3A)
/N_negative_startup_protection/N19_PCLR1: N_U37.8 (3Y), N_U37.12 (4A)
/N_negative_startup_protection/N19_PERMIT: N_U1.5 (Q), N_U16.2 (A1), N_U38.1 (1A)
/N_negative_startup_protection/N19_PERMIT_CLR_N: N_U1.6 (CLR_N), N_U37.11 (4Y)
/N_negative_startup_protection/N19_PERMIT_D: N_U1.2 (D), N_U37.3 (1Y), N_U51.2 (1B)
/N_negative_startup_protection/N19_RAMP: N_C26.1, N_C27.1, N_R72.1, N_U18.18 (RAMP)
/N_negative_startup_protection/N19_READY: N_U38.2 (1B), N_U43.3 (1Y), N_U44.10 (3B), N_U47.3 (2A)
/N_negative_startup_protection/N19_RUN_HOST5: N_R61.1, N_U16.7 (B1), N_U19.7 (INA)
/N_negative_startup_protection/N19_SAFE: N_U36.13 (4B), N_U37.13 (4B), N_U47.1 (1A), N_U51.11 (4Y)
/N_negative_startup_protection/N19_SAFE_SOURCE: N_U42.11 (4Y), N_U51.12 (4A)
/N_negative_startup_protection/N19_SOURCE_SAFE0: N_U42.6 (2Y), N_U42.9 (3A)
/N_negative_startup_protection/N19_SOURCE_SAFE1: N_U42.8 (3Y), N_U42.12 (4A)
/N_negative_startup_protection/N19_SOURCE_UV_GOOD: N_R37.2, N_U14.1 (OUT1), N_U42.4 (2A)
/N_negative_startup_protection/N19_SOURCE_UV_REF: N_R34.2, N_R35.1, N_U14.2 (IN1-)
/N_negative_startup_protection/N19_SOURCE_UV_RMID: N_R33.2, N_R34.1
/N_negative_startup_protection/N19_SOURCE_UV_SENSE: N_R36.2, N_U14.3 (IN1+)
/N_negative_startup_protection/N19_SS: N_C29.1, N_U18.19 (SS)
/N_negative_startup_protection/N19_START: N_J1.19 (N19_START_MONITOR_OUTPUT_ONLY), N_R19.1, N_U29.1 (1A), N_U53.4 (Y)
/N_negative_startup_protection/N19_START_ARMED: N_U36.8 (3Y), N_U36.12 (4A)
/N_negative_startup_protection/N19_START_CONDITIONED: N_U1.1 (CLK), N_U29.4 (2Y)
/N_negative_startup_protection/N19_START_CONDITIONED_BUFFER_MID: N_U29.3 (2A), N_U29.6 (1Y)
/N_negative_startup_protection/N19_START_CT: N_C92.1, N_U52.5 (CT)
/N_negative_startup_protection/N19_START_DELAY_N: N_R90.2, N_U52.6 (RESET_N), N_U53.2 (A)
/N_negative_startup_protection/N19_START_SAFE: N_U36.11 (4Y), N_U37.1 (1A)
/N_negative_startup_protection/N19_TMR: N_C30.1, N_U18.20 (TMR)
/N_negative_startup_protection/N19_VIN: N_C6.1, N_R57.2, N_R58.1, N_R64.1, N_U18.21 (VIN)
/N_negative_startup_protection/N19_VIN_VALID_CT: N_C8.1, N_U21.5 (CT)
/N_negative_startup_protection/N19_VIN_VALID_SENSE: N_R64.2, N_R65.1, N_U21.1 (SENSE)
/N_negative_startup_protection/N19_WDO: N_R1.2, N_U3.7 (WDO), N_U36.10 (3B), N_U47.5 (3A)
/N_negative_startup_protection/N19_WD_ARMED: N_R2.2, N_U3.8 (ENOUT), N_U35.13 (4B), N_U36.9 (3A)
/N_negative_startup_protection/N19_WD_ENABLE: N_U3.3 (EN), N_U35.6 (2Y)
/N_negative_startup_protection/NF_FAULT_REQUEST: N_U46.3 (1Y), N_U46.5 (2B), N_U48.1 (1A)
/N_negative_startup_protection/NF_NOT_OUTPUT_VALID: N_U46.8 (3Y), N_U48.9 (4A)
/N_negative_startup_protection/NF_NO_FAULT: N_U37.2 (1B), N_U37.10 (3B), N_U38.10 (3B), N_U40.10 (3B), N_U41.2 (1B), N_U42.2 (1B), N_U44.6 (2Y)
/N_negative_startup_protection/NF_OUTPUT_VALID_BUFFER_MID: N_U49.3 (2A), N_U49.6 (1Y)
/N_negative_startup_protection/NF_OUTPUT_VALID_HCS: N_U48.8 (4Y), N_U49.1 (1A)
/N_negative_startup_protection/NOT_GLOBAL_VALID: N_U48.10 (5Y), N_U50.2 (1A), N_U50.8 (3A)
/N_negative_startup_protection/NOT_N12_OUTPUT_QUALIFIED: N_U46.10 (3B), N_U48.6 (3Y)
/N_negative_startup_protection/NOT_N19_OUTPUT_QUALIFIED: N_U46.9 (3A), N_U48.4 (2Y)
/N_negative_startup_protection/NOT_NF_FAULT_REQUEST: N_U44.5 (2B), N_U48.2 (1Y)
PWR_AGND: N_C1.2, N_C2.2, N_C3.2, N_C12.2, N_C39.2, N_C55.2, N_C56.2, N_C57.2, N_C58.2, N_C59.2, N_C60.2, N_C61.2, N_C62.2, N_C63.2, N_C64.2, N_C65.2, N_C66.2, N_C67.2, N_C68.2, N_C69.2, N_C70.2, N_C71.2, N_C72.2, N_C73.2, N_C74.2, N_C75.2, N_C76.2, N_C77.2, N_C78.2, N_C79.2, N_C80.2, N_C81.2, N_C82.2, N_C83.2, N_C84.2, N_C85.2, N_C86.2, N_C87.2, N_C88.2, N_C89.2, N_C90.2, N_C91.2, N_C92.2, N_C93.2, N_C94.2, N_C95.2, N_C96.2, N_C97.2, N_C98.2, N_C99.2, N_C100.2, N_J1.2 (AGND), N_R3.2, N_R10.2, N_R15.2, N_R16.2, N_R17.2, N_R18.2, N_R19.2, N_R20.2, N_R21.2, N_R22.2, N_R27.2, N_R31.2, N_R35.2, N_R44.2, N_R47.2, N_R51.2, N_R59.2, N_R61.2, N_R67.2, N_R68.2, N_R76.2, N_R78.2, N_R84.2, N_R85.2, N_R94.2, N_R96.2, N_R97.2, N_U1.4 (GND), N_U2.4 (GND), N_U3.4 (GND), N_U3.9 (EP), N_U4.3 (GND), N_U7.4 (GND), N_U8.4 (GND), N_U9.4 (GND), N_U9.9 (EP), N_U10.3 (GND), N_U13.3 (INA+), N_U13.4 (V-), N_U13.5 (INB+), N_U14.4 (V-), N_U15.12 (V-), N_U16.4 (GND), N_U19.5 (GND2), N_U24.5 (GND2), N_U27.4 (GND), N_U28.3 (GND), N_U29.2 (GND), N_U30.3 (GND), N_U31.2 (GND), N_U32.2 (GND), N_U33.2 (GND), N_U34.2 (GND), N_U35.7 (GND), N_U36.7 (GND), N_U37.7 (GND), N_U38.7 (GND), N_U39.7 (GND), N_U40.7 (GND), N_U41.7 (GND), N_U42.7 (GND), N_U43.7 (GND), N_U44.7 (GND), N_U45.7 (GND), N_U46.7 (GND), N_U47.7 (GND), N_U48.7 (GND), N_U49.2 (GND), N_U50.7 (GND), N_U51.7 (GND), N_U52.2 (GND), N_U53.3 (GND), N_U54.2 (GND), N_U55.3 (GND), N_U56.2 (GND), N_U57.2 (GND), N_U58.3 (GND); also elsewhere on the board
PWR_E28_COMBINED_FAULT_REQUEST: N_J1.14 (E28_COMBINED_FAULT_REQUEST), N_U34.4 (2Y); also elsewhere on the board
PWR_E28_NATIVE_FAULT_REQUEST: N_J1.13 (E28_NATIVE_FAULT_REQUEST), N_U46.4 (2A); also elsewhere on the board
PWR_E28_NOT_FAULT: N_J1.15 (E28_NOT_FAULT), N_R22.1, N_U44.4 (2A); also elsewhere on the board
PWR_E28_RESET: N_U46.13 (4B); also elsewhere on the board
PWR_MODULE_12V: N_C4.1, N_C31.1, N_J6.1 (GUARDED12), N_U17.2 (+VIN), N_U22.2 (+VIN); also elsewhere on the board
PWR_MODULE_INPUT_GND: N_C4.2, N_C31.2, N_J6.2 (MODULE_RETURN), N_U17.1 (-VIN), N_U22.1 (-VIN); also elsewhere on the board
PWR_N12: N_J1.29 (N12_PROTECTED), N_R40.1; also elsewhere on the board
PWR_N12_BANK_COMMON: N_J5.2 (BANK_COMMON), N_U12.6 (D2); also elsewhere on the board
PWR_N12_BANK_GATE: N_J5.1 (BANK_GATE), N_R14.1; also elsewhere on the board
PWR_N12_OV_OK: N_J1.10 (N12_OV_OK), N_U43.5 (2B); also elsewhere on the board
PWR_N12_OV_SENSE: N_J1.12 (N12_OV_SENSE), N_R52.1; also elsewhere on the board
PWR_N12_POST_NF: N_C41.2, N_C42.2, N_C43.2, N_C44.2, N_C45.2, N_C46.2, N_C47.2, N_C48.2, N_C49.2, N_J4.2 (E28_SRC), N_Q2.2 (D), N_R88.1; also elsewhere on the board
PWR_N12_SOURCE: N_C32.2, N_C33.2, N_C34.2, N_C35.2, N_C36.2, N_C37.2, N_C38.2, N_C40.2, N_C50.2, N_C51.2, N_C52.2, N_C53.2, N_C54.2, N_J4.1 (P03_SRC), N_R75.2, N_R76.1, N_R77.2, N_R80.2, N_R82.2, N_R86.1, N_U22.6 (-VOUT), N_U23.1 (PGI), N_U23.3 (ALERT), N_U23.10 (ADIN2), N_U23.11 (OV), N_U23.13 (VEE), N_U23.23 (ADIN), N_U23.24 (ADR0), N_U23.25 (ADR1), N_U23.26 (EN), N_U23.27 (PG), N_U24.4 (GND1), N_U25.2 (GND), N_U26.2 (GND); also elsewhere on the board
PWR_N19: N_J1.23 (N19_PROTECTED), N_R23.1; also elsewhere on the board
PWR_N19_BANK_COMMON: N_J3.2 (BANK_COMMON), N_U6.6 (D2); also elsewhere on the board
PWR_N19_BANK_GATE: N_J3.1 (BANK_GATE), N_R7.1; also elsewhere on the board
PWR_N19_OV_OK: N_J1.9 (N19_OV_OK), N_U42.5 (2B); also elsewhere on the board
PWR_N19_OV_SENSE: N_J1.11 (N19_OV_SENSE), N_R36.1; also elsewhere on the board
PWR_N19_POST_NF: N_C14.2, N_C15.2, N_C16.2, N_C17.2, N_C18.2, N_C19.2, N_C20.2, N_C21.2, N_C22.2, N_C23.2, N_C24.2, N_C25.2, N_J2.2 (E28_SRC), N_Q1.2 (D), N_R71.1; also elsewhere on the board
PWR_N19_SOURCE: N_C5.2, N_C6.2, N_C7.2, N_C8.2, N_C9.2, N_C10.2, N_C11.2, N_C13.2, N_C26.2, N_C27.2, N_C28.2, N_C29.2, N_C30.2, N_J2.1 (P03_SRC), N_R58.2, N_R59.1, N_R60.2, N_R63.2, N_R65.2, N_R69.1, N_U17.6 (-VOUT), N_U18.1 (PGI), N_U18.3 (ALERT), N_U18.10 (ADIN2), N_U18.11 (OV), N_U18.13 (VEE), N_U18.23 (ADIN), N_U18.24 (ADR0), N_U18.25 (ADR1), N_U18.26 (EN), N_U18.27 (PG), N_U19.4 (GND1), N_U20.2 (GND), N_U21.2 (GND); also elsewhere on the board
PWR_NF_AUX_VALID: N_J1.5 (AUX_VALID), N_R16.1, N_U35.1 (1A); also elsewhere on the board
PWR_NF_GLOBAL_MASTER: N_J1.6 (GLOBAL_MASTER), N_R15.1, N_U35.2 (1B); also elsewhere on the board
PWR_NF_INVERTED_COMBINED_FAULT: N_U34.6 (1Y), N_U46.12 (4A)
PWR_NF_MASKED_INVERTED_FAULT: N_U34.3 (2A), N_U46.11 (4Y)
PWR_NF_OUTPUT_VALID: N_J1.30 (NF_OUTPUT_VALID), N_U49.4 (2Y); also elsewhere on the board
PWR_NF_RAW5: N_C39.1, N_C55.1, N_C97.1, N_J1.3 (DIG5_FORCE), N_R95.1, N_U16.8 (VCCB), N_U19.8 (VCC2), N_U24.8 (VCC2), N_U27.1 (VCCA), N_U27.5 (DIR), N_U56.3 (MR), N_U56.4 (VDD), N_U57.1 (IN); also elsewhere on the board
PWR_PROTECT_REF: N_J1.8 (PROTECT_REF), N_R25.1, N_R29.1, N_R33.1, N_R42.1, N_R46.1, N_R49.1; also elsewhere on the board
PWR_V2V5_AUX: N_C3.1, N_C12.1, N_C56.1, N_C57.1, N_C58.1, N_C59.1, N_C60.1, N_C61.1, N_C62.1, N_C63.1, N_C64.1, N_C65.1, N_C66.1, N_C67.1, N_C68.1, N_C69.1, N_C70.1, N_C71.1, N_C72.1, N_C73.1, N_C74.1, N_C75.1, N_C76.1, N_C77.1, N_C78.1, N_C79.1, N_C80.1, N_C81.1, N_C82.1, N_C83.1, N_C84.1, N_C85.1, N_C86.1, N_C87.1, N_C88.1, N_C89.1, N_C90.1, N_C91.1, N_C93.1, N_C94.1, N_C96.1, N_C100.1, N_J1.1 (AUX2V6), N_R1.1, N_R2.1, N_R8.1, N_R9.1, N_R37.1, N_R38.1, N_R39.1, N_R53.1, N_R54.1, N_R55.1, N_R90.1, N_R91.1, N_R92.1, N_U1.7 (PRE_N), N_U1.8 (VCC), N_U2.2 (D), N_U2.7 (PRE_N), N_U2.8 (VCC), N_U3.1 (VDD), N_U4.5 (VCC), N_U7.7 (PRE_N), N_U7.8 (VCC), N_U8.2 (D), N_U8.7 (PRE_N), N_U8.8 (VCC), N_U9.1 (VDD), N_U10.5 (VCC), N_U13.8 (V+), N_U14.8 (V+), N_U15.3 (V+), N_U16.1 (VCCA), N_U16.5 (DIR), N_U27.8 (VCCB), N_U28.5 (VCC), N_U29.5 (VCC), N_U30.5 (VCC), N_U31.5 (VCC), N_U32.5 (VCC), N_U33.5 (VCC), N_U34.5 (VCC), N_U35.14 (VCC), N_U36.14 (VCC), N_U37.14 (VCC), N_U38.14 (VCC), N_U39.14 (VCC), N_U40.14 (VCC), N_U41.14 (VCC), N_U42.14 (VCC), N_U43.14 (VCC), N_U44.14 (VCC), N_U45.14 (VCC), N_U46.14 (VCC), N_U47.14 (VCC), N_U48.14 (VCC), N_U49.5 (VCC), N_U50.14 (VCC), N_U51.14 (VCC), N_U52.3 (MR), N_U52.4 (VDD), N_U53.5 (VCC), N_U54.3 (MR), N_U54.4 (VDD), N_U55.5 (VCC), N_U58.5 (VCC); also elsewhere on the board

Notes on the sheet:
NF06P: captured265-part NF05R circuit with explicit physical-land/connector proposals.
Actual primitive/MPN heights, complete tolerances, routing, return coupling and installed assembly require fresh review.
Prototype only; physical/partial-power/faultenergy/fabrication acceptance FALSE.

Schematic: F_fan_power_health.kicad_sch, Standalone RMX - fan_power_health

Parts:
F_C1, F_C2: 10uF 25V C3225X7R1E106K250AC; Capacitor_SMD__C_1210_3225Metric
F_C3, F_C14, F_C22, F_C23: 10nF 50V C0G C1206C103J5GACTU; Capacitor_SMD__C_1206_3216Metric
F_C4, F_C5, F_C6, F_C8, F_C9, F_C10, F_C11, F_C12, F_C13, F_C15, F_C16, F_C17, F_C18, F_C19, F_C24: 100nF 25V C0G C1206C104J3GACTU; Capacitor_SMD__C_1206_3216Metric
F_C7: 2.7nF 50V C0G5% C0603C272J5GACTU; Capacitor_SMD__C_0603_1608Metric
F_C20, F_C21: 15pF 50V C0G5% C0603C150J5GACTU; Capacitor_SMD__C_0603_1608Metric
F_C201, F_C202, F_C301, F_C302: 100nF25V C0G5% C1206C104J3GACTU; Capacitor_SMD__C_1206_3216Metric
F_C203, F_C303: 1uF63V10% WIMA MKS2C041001F00KSSD; Capacitor_THT__C_Rect_L7.2mm_W5.0mm_P5.00mm
F_C401, F_C402, F_C403, F_C404: 100nF50V X7R10% C0603C104K5RACTU - EFFECTIVE60nF_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; Capacitor_SMD__C_0603_1608Metric
F_J2, F_J3, F_J4, F_J201: JST B2B-XH-A / XHP-2 / SXH-001T-P0.6; Connector_JST__JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
F_J5: AVRISP2x3 target-powered3.3V sense ONLY; Connector_PinHeader_2.54mm__PinHeader_2x03_P2.54mm_Vertical
F_J202, F_J203: JST B3B-XH-A / XHP-3 / SXH-001T-P0.6; Connector_JST__JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
F_J401: JST B2B-PH-K-S / PHR-2 / SPH-002T-P0.5S; Connector_JST__JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
F_R1, F_R16, F_R17, F_R21, F_R23: 1k 0.1%25ppm TNPW08051K00BEEA; Resistor_SMD__R_0805_2012Metric
F_R2, F_R6, F_R10, F_R13, F_R202, F_R302: 10k 0.1%25ppm TNPW080510K0BEEA; Resistor_SMD__R_0805_2012Metric
F_R3, F_R4, F_R5, F_R7, F_R14, F_R15: 47k 0.1%25ppm TNPW080547K0BEEA; Resistor_SMD__R_0805_2012Metric
F_R8: 68k 0.1%25ppm TNPW080568K0BEEA; Resistor_SMD__R_0805_2012Metric
F_R9: 39k 0.1%25ppm TNPW080539K0BEEA; Resistor_SMD__R_0805_2012Metric
F_R11: 56.2k 0.1%25ppm TNPW080556K2BEEA; Resistor_SMD__R_0805_2012Metric
F_R12, F_R24, F_R201, F_R203, F_R301, F_R303: 100k 0.1%25ppm TNPW0805100KBEEA; Resistor_SMD__R_0805_2012Metric
F_R20, F_R22: 20k 0.1%25ppm TNPW080520K0BEEA; Resistor_SMD__R_0805_2012Metric
F_R401: 220k 0.1%25ppm TNPW0805220KBEEA - COMPLETE1% RECE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; Resistor_SMD__R_0805_2012Metric
F_U1: ATtiny84A-SSUR; Package_SO__SOIC-14_3.9x8.7mm_P1.27mm
F_U2: TPS7A1633DGNR; TI_DGN0008C
F_U3: SN74LVC2G17DCKR; Package_TO_SOT_SMD__SOT-363_SC-70-6
F_U4: TPS3431SDRBR; TI_DRB0008A_TPS3431
F_U5: SN74AUP1G17DCKR; Package_TO_SOT_SMD__SOT-353_SC-70-5
F_U6: SN74LVC1T45DBVR; Package_TO_SOT_SMD__SOT-23-6
F_U7: SN74LVC1G14DCKR; Package_TO_SOT_SMD__SOT-353_SC-70-5
F_U8: SN74LVC1G74DCUR; TI_DCU0008A
F_U9: TPS389001DSET; Package_SON__WSON-6_1.5x1.5mm_P0.5mm
F_U10, F_U11: SN74LVC1G17DCKR; Package_TO_SOT_SMD__SOT-353_SC-70-5
F_U12, F_U13: SN74LVC1G08DCKR; Package_TO_SOT_SMD__SOT-353_SC-70-5
F_U14: SN74LVC1G06DCKR; Package_TO_SOT_SMD__SOT-353_SC-70-5
F_U15: TLP175A(TPL,E); RMX_FH02__TLP175A_11-4M1S_Receiving
F_U16: SN74LVC1G34DCKR; Package_TO_SOT_SMD__SOT-353_SC-70-5
F_U201, F_U301: TPS2553DBVR-1; Package_TO_SOT_SMD__SOT-23-6
F_U401: TPS2553DBVR-1; TI_DBV0006A
F_X1: ABLS-4.000MHZ-12-D4Y-T; RMX_FH02__ABLS_Manufacturer_Land

Connections:
/F_fan_health_protection/FAN_L_5V: F_C203.1, F_J202.2 (FAN_L_5V), F_R202.1, F_R203.1, F_U201.6 (OUT)
/F_fan_health_protection/FAN_L_ILIM: F_R201.1, F_U201.5 (ILIM)
/F_fan_health_protection/FAN_L_TACH: F_J202.3 (FAN_L_TACH), F_R14.1, F_R202.2, F_U3.1 (1A)
/F_fan_health_protection/FAN_R_5V: F_C303.1, F_J203.2 (FAN_R_5V), F_R302.1, F_R303.1, F_U301.6 (OUT)
/F_fan_health_protection/FAN_R_ILIM: F_R301.1, F_U301.5 (ILIM)
/F_fan_health_protection/FAN_R_TACH: F_J203.3 (FAN_R_TACH), F_R15.1, F_R302.2, F_U3.3 (2A)
/F_fan_health_protection/FAULT_CLK: F_U7.4 (Y), F_U8.1 (CLK)
/F_fan_health_protection/HEALTH_AND_WD: F_U12.4 (Y), F_U13.1 (A)
/F_fan_health_protection/HEARTBEAT: F_R4.1, F_U1.11 (PA2), F_U16.2 (A)
/F_fan_health_protection/HEARTBEAT_FAST: F_U4.6 (WDI), F_U16.4 (Y)
/F_fan_health_protection/HW_NOFAULT: F_U11.4 (Y), F_U13.2 (B)
/F_fan_health_protection/HW_NOFAULT_5: F_R9.1, F_U8.3 (Q_N), F_U11.2 (A)
/F_fan_health_protection/ISP_MISO: F_J5.1 (ISP_MISO), F_U1.8 (PA5_MISO)
/F_fan_health_protection/ISP_MOSI: F_J5.4 (ISP_MOSI), F_U1.7 (PA6_MOSI)
/F_fan_health_protection/ISP_SCK: F_J5.3 (ISP_SCK), F_U1.9 (PA4_SCK)
/F_fan_health_protection/LDO_DELAY: F_C3.1, F_U2.7 (DELAY)
/F_fan_health_protection/LEAF_PERMISSION: F_R13.1, F_U13.4 (Y), F_U14.2 (A)
/F_fan_health_protection/LED_A: F_R1.2, F_R2.1, F_U15.1 (LED_A)
/F_fan_health_protection/LED_K: F_R2.2, F_U14.4 (Y), F_U15.3 (LED_K)
/F_fan_health_protection/MCU_HEALTH: F_R3.1, F_U1.6 (PA7), F_U12.1 (A)
/F_fan_health_protection/MCU_RESET_N: F_J5.5 (MCU_RESET_N), F_R6.2, F_U1.4 (PB3_RESET_N)
/F_fan_health_protection/MCU_TACH_L: F_R16.2, F_U1.10 (PA3)
/F_fan_health_protection/MCU_TACH_R: F_R17.2, F_U1.5 (PB2)
/F_fan_health_protection/NF_RAW5_ILIM: F_R401.1, F_U401.5 (ILIM)
/F_fan_health_protection/RAW_CLEAR_FAST: F_U8.6 (CLR_N), F_U10.4 (Y)
/F_fan_health_protection/RAW_CLEAR_N: F_R10.2, F_U9.6 (RESET_N), F_U10.2 (A)
/F_fan_health_protection/RAW_POR_CT: F_C14.1, F_U9.5 (CT)
/F_fan_health_protection/RAW_POR_SENSE: F_R11.2, F_R12.1, F_U9.1 (SENSE)
/F_fan_health_protection/TACH_L_BUF: F_R16.1, F_U3.6 (1Y)
/F_fan_health_protection/TACH_R_BUF: F_R17.1, F_U3.4 (2Y)
/F_fan_health_protection/TEMP_L_ADC: F_C22.1, F_R21.2, F_U1.13 (PA0_ADC0)
/F_fan_health_protection/TEMP_L_NODE: F_J2.1 (SENSOR), F_R20.2, F_R21.1
/F_fan_health_protection/TEMP_R_ADC: F_C23.1, F_R23.2, F_U1.12 (PA1_ADC1)
/F_fan_health_protection/TEMP_R_NODE: F_J3.1 (SENSOR), F_R22.2, F_R23.1
/F_fan_health_protection/V3V3: F_C2.1, F_C4.1, F_C5.1, F_C6.1, F_C8.1, F_C9.1, F_C16.1, F_C17.1, F_C18.1, F_C19.1, F_C24.1, F_J5.2 (V3V3), F_R5.1, F_R6.1, F_R7.1, F_R20.1, F_R22.1, F_R24.1, F_U1.1 (VCC), F_U2.1 (OUT), F_U3.5 (VCC), F_U4.1 (VDD), F_U4.5 (SET1), F_U5.5 (VCC), F_U6.1 (VCCA), F_U6.5 (DIR), F_U11.5 (VCC), F_U12.5 (VCC), F_U13.5 (VCC), F_U14.5 (VCC), F_U16.5 (VCC)
/F_fan_health_protection/WD_CWD: F_C7.1, F_U4.2 (CWD)
/F_fan_health_protection/WD_EN: F_R7.2, F_U4.3 (EN)
/F_fan_health_protection/WD_OK: F_R5.2, F_U2.3 (PG), F_U4.7 (WDO_N), F_U4.8 (ENOUT), F_U5.2 (A)
/F_fan_health_protection/WD_OK_5: F_R8.1, F_U6.4 (B), F_U7.2 (A)
/F_fan_health_protection/WD_OK_FAST: F_U5.4 (Y), F_U6.3 (A), F_U12.2 (B)
/F_fan_health_protection/XTAL1: F_C20.1, F_U1.2 (PB0_XTAL1), F_X1.1 (XTAL1)
/F_fan_health_protection/XTAL2: F_C21.1, F_U1.3 (PB1_XTAL2), F_X1.2 (XTAL2)
PWR_5V_DIG_SRC: F_C1.1, F_C10.1, F_C11.1, F_C12.1, F_C13.1, F_C15.1, F_C201.1, F_C202.1, F_C301.1, F_C302.1, F_C401.1, F_C402.1, F_J201.1 (FAN5V_IN), F_R1.1, F_R10.1, F_R11.1, F_U2.5 (EN), F_U2.8 (IN), F_U6.6 (VCCB), F_U7.5 (VCC), F_U8.2 (D), F_U8.7 (PRE_N), F_U8.8 (VCC), F_U9.3 (MR_N), F_U9.4 (VDD), F_U10.5 (VCC), F_U201.1 (IN), F_U201.3 (EN), F_U301.1 (IN), F_U301.3 (EN), F_U401.1 (IN), F_U401.3 (EN); also elsewhere on the board
PWR_AGND: F_C1.2, F_C2.2, F_C3.2, F_C4.2, F_C5.2, F_C6.2, F_C7.2, F_C8.2, F_C9.2, F_C10.2, F_C11.2, F_C12.2, F_C13.2, F_C14.2, F_C15.2, F_C16.2, F_C17.2, F_C18.2, F_C19.2, F_C20.2, F_C21.2, F_C22.2, F_C23.2, F_C24.2, F_C201.2, F_C202.2, F_C203.2, F_C301.2, F_C302.2, F_C303.2, F_C401.2, F_C402.2, F_C403.2, F_C404.2, F_J2.2 (GND), F_J3.2 (GND), F_J5.6 (GND), F_J201.2 (FAN_GND), F_J202.1 (FAN_GND), F_J203.1 (FAN_GND), F_J401.2 (GND), F_R3.2, F_R4.2, F_R8.2, F_R9.2, F_R12.2, F_R13.2, F_R14.2, F_R15.2, F_R24.2, F_R201.2, F_R203.2, F_R301.2, F_R303.2, F_R401.2, F_U1.14 (GND), F_U2.4 (GND), F_U2.9 (EP), F_U3.2 (GND), F_U4.4 (GND), F_U4.9 (EP), F_U5.3 (GND), F_U6.2 (GND), F_U7.3 (GND), F_U8.4 (GND), F_U9.2 (GND), F_U10.3 (GND), F_U11.3 (GND), F_U12.3 (GND), F_U13.3 (GND), F_U14.3 (GND), F_U16.3 (GND), F_U201.2 (GND), F_U301.2 (GND), F_U401.2 (GND); also elsewhere on the board
PWR_NF_RAW5: F_C403.1, F_C404.1, F_J401.1 (NF_RAW5), F_U401.6 (OUT); also elsewhere on the board
PWR_RUN_AFTER_FAN: F_J4.2 (TO_E28_J5_3), F_U15.6 (CONTACT_B); also elsewhere on the board
PWR_RUN_BEFORE_FAN: F_J4.1 (FROM_P03_J106_3), F_U15.4 (CONTACT_A); also elsewhere on the board

Notes on the sheet:
FPC_M2 private successor: third protected NF RAW5 leaf; all84 parent circuits/poses unchanged.
RAW5 operating P03J23/J21 ONLY, neverTESTJ3. No full-source/inrush/physical/PDN acceptance.
